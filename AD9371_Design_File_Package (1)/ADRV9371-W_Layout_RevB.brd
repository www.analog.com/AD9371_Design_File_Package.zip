# Allegro board ADRV9371-W_Layout_RevB.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
AGND on L7_SIG: 0,12.7 0,81.79 148.44,81.79 148.44,12.7 ; 17 cut-outs
AGND on L8_SIG: 0,12.7 0,81.79 148.44,81.79 148.44,12.7 ; 18 cut-outs
AGND on L10_SIG: 0,12.7 0,81.79 148.44,81.79 148.44,12.7 ; 12 cut-outs
VDD_IF on TOP: 50.75,15.91 49.92,15.92 49.41,15.41 49.41,14.27 48.9,13.76 45.86,13.76 45.35,14.27 45.35,16.05 45.98,16.68 47.38,16.68 49.54,18.84 52.71,18.84 52.84,18.72 52.84,17.48 52.81,17.48 52.81,15.98 52.71,15.88 51.62,15.88 51.49,16.01 50.78,16.01 50.75,15.98
VDD_IF on L12_PWR: 75.7,34.84 63.76,22.91 54.89,22.91 51.68,19.73 46.11,19.73 44.84,18.46 44.84,13.51 45.35,13 68.84,13 80.91,25.07 80.91,30.91 89.04,39.04 122.69,39.04 125.23,36.5 126.37,36.5 138.19,48.31 138.19,53.01 137.8,53.39 103.51,53.39 98.82,58.09 77.61,58.09 75.7,56.18
VDD_IF_LDO on TOP: 58.05,15.83 58.12,15.91 59.98,15.91 60.21,16.14 60.21,18.33 59.57,18.97 56.78,18.97 56.78,17.45 56.31,16.98 55.89,16.98 55.84,16.93 55.84,15.97 55.98,15.83
1P3_BUCK_OUT on BOTTOM: 80.07,21.37 80.07,18 79.92,17.84 71.54,17.84 71.46,17.92 71.46,21.35 71.59,21.48 79.97,21.48
3P3V_CLK on BOTTOM: 109.48,30.65 109.48,33.32 109.61,33.45 110.88,33.45 112.09,32.24 112.09,30.84 111.64,30.4 109.74,30.4
3P3V_CLK on L3_PWR: 146.34,31.86 128.41,31.86 125.87,34.4 121.87,34.4 119.96,32.5 114.12,32.5 112.28,30.65 109.74,30.65 109.1,31.29 109.1,39.54 111.64,42.08 137.52,42.08 140.79,45.36 140.79,62.12 139.09,63.82 106.79,63.82 106.08,63.17 87.51,63.17 80.78,69.9 80.78,76.75 80.27,77.26 74.3,77.26 74.05,77.52 74.05,80.44 74.3,80.69 99.32,80.69 107.48,72.53 144.91,72.57 147.38,70.1 147.38,32.91
3P3V_CLK on L10_SIG: 81.92,67.19 82.44,66.67 97.3,66.67 97.75,67.13 97.75,80.23 97.16,80.82 82.43,80.82 81.92,80.31
3P3V_VCO on L3_PWR: 108.6,79.51 108.6,74.69 108.78,74.51 126.91,74.51 127.24,74.84 127.24,79.51 126.99,79.77 108.85,79.77
3P3VAUX on L12_PWR: 112.4,33.83 112.4,29.26 112.87,28.79 126.53,28.79 126.83,29.1 139.59,29.1 139.76,29.27 139.76,34.05 139.46,34.35 112.93,34.35
BAL_TX1+ on TOP (solid shape): 34.51,58.62 34.72,58.19 34.8,57.71 34.8,56.72 34.77,56.67 34.72,56.65 34.06,56.65 34,56.67 33.98,56.72 33.98,57.71 33.94,58.13 33.79,58.53 33.81,59.76 34.51,59.76
BAL_TX2+ on TOP (solid shape): 35.62,36.9 35.67,36.88 35.69,36.83 35.69,35.85 35.73,35.42 35.88,35.02 35.87,34.18 35.16,34.18 35.17,34.93 34.96,35.37 34.88,35.84 34.88,36.83 34.9,36.88 34.95,36.9
FMCA_VADJ on L12_PWR: 127.04,21.83 127.04,19.24 127.14,19.14 132.83,19.14 133.03,19.34 133.03,21.27 133.82,22.06 139.2,22.06 139.43,22.29 139.43,24.57 139.31,24.7 130.75,24.7 130.7,24.65 130.7,22.21 130.44,21.96 127.17,21.96
FMCA_VCC_3P3V on L12_PWR: 126.96,22.64 127.05,22.56 130.05,22.56 130.16,22.67 130.16,25.03 130.57,25.44 139.26,25.44 139.84,24.85 139.84,21.91 139.94,21.81 142.68,21.81 142.79,21.91 142.79,28.18 142.58,28.38 127.04,28.38 126.96,28.31
FMCA_VCC_12P0V on TOP: 120.67,22.39 130.18,22.39 132.07,24.28 132.07,24.92 132.49,25.34 142.48,25.34 142.61,25.46 142.61,29.25 142.43,29.43 140.86,29.43 140.75,29.32 140.75,28.65 140.34,28.24 130.31,28.24 129.17,27.1 124.98,27.1 123.83,28.24 117.74,28.24 117.48,27.99 117.48,25.57
INPUT_VOLTAGE on TOP: 125.61,19.35 117.55,19.35 117.17,18.97 117.17,16.81 117.55,16.43 125.61,16.43 125.93,16.75 125.93,19.03
INPUT_VOLTAGE on BOTTOM: 85.71,28.97 84.95,28.97 84.87,28.89 84.87,28.54 84.82,28.49 83.5,28.49 83.45,28.54 83.05,28.54 82.87,28.71 82.87,32.78 82.89,32.8 84.65,32.8 84.7,32.75 84.7,31 85.76,29.93 85.76,29.02
INPUT_VOLTAGE on BOTTOM: 100.77,27.37 100.77,23.13 100.67,23.03 98.54,23.03 98.42,23.14 98.42,27.43 98.49,27.5 100.65,27.5
INPUT_VOLTAGE on BOTTOM: 85.86,19.32 85.76,19.22 83.93,19.22 83.83,19.32 83.83,21.5 84.98,22.64 86.02,22.64 86.07,22.59 86.07,21.63 85.86,21.42
INPUT_VOLTAGE on L12_PWR: 102.24,27.35 117.61,27.35 125.93,19.03 125.93,16.75 125.1,15.92 106.68,15.92 103.89,18.72 84.69,18.72 82.89,20.51 82.89,30.99 85.29,33.38 96.21,33.38
UNNAMED_5_CAP_I900_N2 on BOTTOM: 107.28,73.47 107.28,71.92 107.18,71.82 105.58,71.82 105.52,71.87 105.52,73.47 105.58,73.52 107.23,73.52
UNNAMED_8_ADP5054_I118_SW11 on BOTTOM: 84.9,28.13 84.9,27.24 84.85,27.19 83.32,27.19 81.83,25.69 81.29,25.69 80.78,25.18 80.78,24.68 80.66,24.55 79.95,24.55 79.82,24.68 79.44,24.68 79.39,24.73 79.39,25.64 80.38,26.63 80.38,30.39 80.45,30.47 82.16,30.47 82.26,30.37 82.26,28.44 82.41,28.28 83.86,28.28 83.99,28.16 84.87,28.16
UNNAMED_8_ADP5054_I118_SW21 on BOTTOM: 84.06,22.95 82.99,21.88 82.99,17.79 82.94,17.74 80.66,17.74 80.58,17.82 80.58,23.18 80.28,23.48 80.28,24.04 80.3,24.07 81.01,24.07 81.37,23.71 82.77,23.71 83.05,23.99 84.85,23.99 84.9,23.94 84.9,23.28 84.57,22.95
UNNAMED_8_ADP5054_I118_SW31 on BOTTOM: 97.85,25.77 92.7,25.77 92.57,25.9 92.57,27.29 92.62,27.34 97.85,27.34 97.9,27.29 97.9,25.82
UNNAMED_8_ADP5054_I118_SW41 on BOTTOM: 93.71,23.48 92.54,23.48 92.49,23.53 92.49,25.03 92.72,25.26 97.83,25.26 97.88,25.21 97.88,23.28 97.8,23.2 93.99,23.2
UNNAMED_8_CAP_I101_N1 on BOTTOM: 79.82,30.26 79.82,26.89 79.67,26.73 70.73,26.73 70.65,26.81 70.65,28 71.01,28.36 71.01,29.71 71.11,29.81 72.76,29.81 73.32,30.37 79.72,30.37
UNNAMED_8_CAP_I945_N1 on BOTTOM: 94.09,20.89 94.09,22.39 94.17,22.47 101.41,22.47 101.64,22.69 104.97,22.69 105.02,22.64 105.02,19.22 104.86,19.06 96.35,19.06 96.3,19.11 96.3,20.76 96.23,20.84 94.15,20.84
UNNAMED_8_CAP_I1036_N1 on BOTTOM: 94.09,29.58 94.09,28.08 94.17,28 101.41,28 101.64,27.77 107.07,27.77 107.07,29.05 104.91,31.2 100.75,31.2 100.55,31.41 96.35,31.41 96.3,31.36 96.3,29.71 96.23,29.63 94.15,29.63
UNNAMED_8_CN2P_I1027_N1 on TOP: 111.83,28.05 111.83,24.56 113.04,23.35 113.04,21.19 112.34,20.49 109.99,20.49 109.36,21.13 109.36,27.99 109.61,28.24 111.64,28.24
UNNAMED_8_DIO_I32_P on TOP: 113.42,28.24 113.23,28.05 113.23,23.99 114.06,23.16 114.06,21.26 114.82,20.49 122.31,20.5 122.82,21 122.82,23.03 122.31,23.54 118.75,23.54 116.47,25.83 116.47,27.99 116.21,28.24
VOUT1_1V3_ANLG on BOTTOM: 32.58,29.32 32.58,27.54 32.24,27.19 31.82,27.19 31.66,27.35 31.66,29.29 31.79,29.42 32.49,29.42
VOUT1_1V3_ANLG on BOTTOM: 42.05,33.19 41.79,33.45 40.9,33.45 40.65,33.19 40.65,32.3 40.9,32.05 41.79,32.05 42.05,32.3
VOUT1_1V3_ANLG on BOTTOM: 68.41,26.79 61.38,26.82 59.95,28.24 54.75,28.24 53.6,29.38 53.6,30.02 66.68,30.02 66.94,29.76 70.24,29.76 70.45,29.56 70.45,28.83
VOUT1_1V3_ANLG on L8_SIG: 60.84,29.64 66.15,29.64 66.4,29.38 66.4,26.95 66.18,26.72 60.84,26.72 60.46,27.1 60.46,29.26
VOUT1_1V3_ANLG on L12_PWR: 8.14,25.95 12.73,21.36 50.02,21.36 54.75,26.08 64.65,26.08 66.68,28.11 66.68,28.75 63.26,32.18 51.7,32.18 48.51,28.99 46.63,28.99 45.09,30.53 45.09,40.05 43.19,41.96 41.79,41.96 39.76,39.92 36.59,39.92 33.13,36.47 33.16,28.27 32.87,27.99 32.78,27.99 32.14,28.62 31.66,28.62 31.16,28.11 27.47,28.11 18.93,36.65 18.93,53.77 13.73,58.97 13.73,60.24 10.8,63.17 9.41,63.17 8.14,61.9 ; 1 cut-out
VOUT2_1V3_DIG on BOTTOM, L5_SIG: 71,21.51 71,18.72 70.88,18.59 66.56,18.59 63.89,21.26 63.89,22.65 64.02,22.78 66.18,22.78 67.32,21.64 70.88,21.64
VOUT2_1V3_DIG on L8_SIG: 67.73,18.54 70.98,18.54 71.08,18.64 71.08,21.05 68.46,23.67 63.64,23.67 63.13,23.16 63.13,21 64.27,19.86 66.4,19.86
VOUT3_3V3 on TOP: 56.78,19.86 56.78,21.13 57.44,21.79 59.55,21.79 59.83,21.51 59.83,19.99 59.57,19.73 56.91,19.73
VOUT3_3V3 on BOTTOM: 107.32,34.97 108.85,33.45 108.85,32.05 108.56,31.76 101.31,31.76 101.23,31.84 101.23,33.06 101.28,33.11 101.71,33.11 101.99,33.38 101.99,35.99 102.75,36.75 104.28,36.75 106.05,34.97
VOUT3_3V3 on L3_PWR: 29.09,51.74 28.84,51.99 28.84,53.01 29.09,53.26 36.46,53.26 43.06,59.86 86.62,59.86 105.04,41.45 105.04,33.19 103.39,31.54 99.45,31.54 97.93,33.07 60.21,33.07 56.31,36.97 56.31,50.12 54.7,51.74
VOUT3_3V3 on L10_SIG: 71.04,20.33 76.08,15.29 93.86,15.29 102.32,23.75 102.32,25.27 105.55,28.49 105.55,33.57 104.15,34.97 102.63,34.97 101.99,34.34 101.99,33.83 101.23,33.07 97.29,33.07 92.46,28.23 61.61,28.25 57.03,23.67 57.03,20.62 57.92,19.73 60.08,19.73 60.73,20.38
VOUT4_1V8 on BOTTOM: 42.49,36.88 43.44,37.83 43.44,38.27 43.25,38.46 41.98,38.46 41.54,38.02 41.54,37.07 41.73,36.88
VOUT4_1V8 on BOTTOM: 107.2,18.66 105.22,18.66 105.14,18.58 101.23,18.58 101.23,17.36 101.28,17.31 102,17.31 102.18,17.13 102.18,15.17 102.5,14.86 105.06,14.86 105.19,14.98 105.19,16.68 105.37,16.86 107.15,16.86 107.27,16.99 107.27,18.58
VOUT4_1V8 on BOTTOM: 32.14,69.26 31.12,70.28 31.12,70.53 31.38,70.79 32.9,70.79 33.16,70.53 33.16,70.02 32.9,69.77 32.9,69.52 32.65,69.26
VOUT4_1V8 on L3_PWR: 81.42,19.99 104.28,19.99 105.29,18.97 105.29,14.65 104.28,13.64 49.94,13.64 43.34,20.24 19.19,20.24 14.54,24.89 14.54,60.55 24.77,70.79 32.78,70.79 33.92,69.64 33.92,67.61 33.79,67.48 29.73,67.48 28.2,65.96 28.2,56.69 26.68,55.16 26.68,50.34 28.08,48.94 28.08,28.88 30.74,26.21 37.46,26.21 37.97,26.72 37.97,32.04 41.73,35.8 41.73,38.53 41.92,38.72 43.38,38.72 45.48,36.62 45.48,30.49 47.58,28.38 55.8,28.38 61.65,22.53 78.88,22.53

Small or netless copper shapes (teardrops, artwork): 10 on TOP, 9 on BOTTOM

## Text on the board
Ref Des/Silkscreen Bottom: RX_EXTLO | TX_EXTLO | RX1 | ORX1 | RX2 | ORX2 | SNRXA | TX1 | TX2
Ref Des/Silkscreen Top: STATUS1 | STATUS2 | TX2_ENABLE | RX2_ENABLE | POWER_OK | VOUT3_3V3 | VOUT4_1V8 | SPI_DOUT_9528 | REF_CLK_IN | 6.0-12.0V DC | 2A MAX | FMCA_VCC_12P0V | RESETB | SYNCOUTB0+ | SYNCOUTB0- | FMCA_VCC_3P3V | SYNCINB0- | SYNCINB0+ | VDD_IF | GPIO_3P3 | 5 | GND | 4 | 11 | 3 | 10 | 2 | 1 | 9 | VOUT2_1V3_DIG | VOUT1_1V3_ANLG | 0 | 8 | 7 | 6 | TX1_ENABLE | GPIO_17 | GPIO_18 | RX1_ENABLE | GPIO_15 | GPIO_16 | AUXADC2 | AUXADC3 | GPIO_14 | GPIO_13 | AUXADC0 | AUXADC1 | GPIO_12 | GPIO_11 | GPIO_9 | GPIO_10 | GPIO_8 | GPIO_7 | GPIO_6 | GPIO_5 | GPIO_4 | GPIO_3 | GPIO_2 | GPIO_1 | GPIO_0 | V_IN | SPI_DOUT | SYNCINB1+ | SPI_DOUT_9370 | SYNCINB1- | SPI_CLK | SPI_CSI | FMCA_VADJ | SPI_CS0 | SPI_DIN | GP_INTERRUPT | RX_EXTLO | TX_EXTLO | 9370CE04A | ORX1 | RX1 | RX2 | ORX2 | POWER_IN | SNRXA | TX1 | TX2 | ADRV9371-W/PCBZ
DIMENSION: PRE-ROUTES (2 PLACES) | 0.062" WIDE | .087" | 30 DEGREES BOTH SIDES | SCORE DETAIL | SCORE EDGE | WEB .020 +/- .004
PAGE_OUTLINE: B | AS PER ECR-066655 | 17JAN17 | T. KARPUS
User.15: CHARACTERISTIC IMPEDANCE = 100 OHMS +/- 10% DIFF PAIR | ARTWORK LINE WIDTH FOR | IMPEDANCE CONTROLLED LINES = 0.008"/0.006 AND 0.0036"/0.0064" | CHARACTERISTIC IMPEDANCE = 50 OHMS +/- 10% DIFF PAIR | IMPEDANCE CONTROLLED LINES = 0.032"/0.004" | ISOLA 370HR | ROGERS4003 | 50 OHMS 0.0045" SINGLE ENDED / 100 OHMS 0.0036"/0.0064" DIFF | 50 OHMS 0.0155" SINGLE ENDED; 0.032"/0.004" DIFF | 50 OHMS 0.0155" SINGLE ENDED / 100 OHMS 0.008"/0.006" DIFF | 100 OHMS 0.008"/0.006" DIFF | SEE NOTE 15
User.17: 08-      -07 | L2 GND
User.18: L3 PWR | 08-      -08
User.19: L4 GND | 08-      -09
User.20: 08-      -10 | L5 SIG
User.22: 08-      -11 | L6 GND
User.23: 08-      -12 | L7 SIG
User.24: 08-      -13 | L8 SIG
User.25: 08-      -14 | L9 GND
User.26: 08-      -15 | L10 SIG
User.27: L11 GND | 08-      -16
User.28: L12 PWR | 08-      -17
User.29: 08-      -18 | L13 GND
User.45: FIGURE | SIZE | 8.0 | 6.01 | 10.01 | 10.02 | 6.0 | 10.0 | 20.0 | 40.0 | 45.0 | 60.0 | 65.0 | 50.0 | 100.0 | 160.0 | PLATED | NON-PLATED | BACKDRILL: TOP to L9_GND | ALL UNITS ARE IN MILS | BACKDRILL: TOP to L4_GND | DRILL CHART: TOP to L10_SIG | DRILL CHART: BOTTOM to L11_GND | DRILL CHART: TOP to BOTTOM | QTY | 6 | 110 | 77 | 17 | 151 | 90 | 271 | 1074 | 171 | 20 | 59 | 5 | 2 | TOLERANCE/NOTES
