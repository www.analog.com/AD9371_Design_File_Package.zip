# Allegro board ADRV9371-N_PCBZ_Layout_RevB.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
VDD_IF: length 250.6
  TOP w0.203: v1(117.49,60.57) 117.21,60.84 U403.8
  TOP w0.254: U101.M12 v2(38.04,50.78)
  TOP w0.305: R606.1 55.25,26.09 v1(56.78,24.56) ; R739.2 50.3,16.65 ; U702.2 51.35,15.99 51.03,16.31 ; R510.1 93.34,49.45 98.32,49.45 100.09,51.22 v1(100.09,52.12) 100.09,52.69 R512.1 ; v1(123.51,32.78) 122.53,33.76 U404.1 120.98,33.76 120.51,34.24 120.51,34.57 120.01,35.06 U404.4 ; U405.1 118.84,60.76 118.64,60.57 v1(117.49,60.57) ; 51.01,17.05 51.41,16.64 U702.1 ; R513.1 97.56,57.13 v1(97.05,57.64) ; R808.1 R809.1 137.92,53.04 v2(137.83,52.96) ; R511.1 v1(94.81,57.64) ; U405.8 v1(122.74,66.3)
  TOP w0.394: R503.1 132.75,25.02 v2(132.75,25.02) ; P504.1 v1(43.47,72.38)
  TOP w0.508: 45.92,15.29 P707.1 ; P707.1 47,14.21 ; P707.1 48.08,15.29 ; P707.1 47,16.37
  TOP w0.762: R738.2 131.45,22.45 v1(131.48,22.48)
  L3_PWR w0.508: v1(94.81,57.64) 95.64,58.46 96.52,58.46 97.05,57.93 v1(97.05,57.64) 100.09,54.61 v1(100.09,52.12)
  L3_PWR w0.635: 123.51,29.8 122.21,28.49 119.45,28.49 118.91,27.96 95.23,27.96 93.51,29.67 85.83,29.67 85.37,30.12 80.03,30.12 v1(78.75,31.41) 77.87,31.41 v1(77.86,31.42) v1(77.1,31.42) ; 123.51,29.8 v1(123.51,32.78) ; 123.51,29.8 127.04,26.27 131.5,26.27 v2(132.75,25.02) 132.75,23.75 v1(131.48,22.48)
  L12_PWR w0.203: 56.78,22.65 v1(56.78,24.56)
  L12_PWR w0.508: 47,14.21 P707.1 ; P707.1 47,16.37 ; P707.1 45.92,15.29 ; P707.1 48.08,15.29 ; 125.36,52.88 125.36,59.86 122.74,62.49 v1(122.74,66.3) ; v1(117.49,60.57) 116.28,60.57 115.2,59.48 115.2,53.13
  L12_PWR w0.762: v1(43.47,72.38) 45.56,74.47 68.34,74.47 69.99,72.82 69.99,68.5 71.38,67.1 71.38,61.39 72.65,60.12 76.97,60.12 78.5,58.59 78.5,57.7 ; 76.08,55.67 48.27,55.67 45.53,52.94 43.63,52.94 41.47,50.78 v2(38.04,50.78)
  BOTTOM w0.305: C642.1 38.05,52.33 C643.1 ; C642.1 38.05,50.79 v2(38.04,50.78) ; C642.1 R502.1
  BOTTOM w0.394: P801.J39 v2(132.75,25.02) ; v1(125.61,36.88) 125.61,36.24 123.51,34.14 v1(123.51,32.78) 123.26,32.78 122.7,33.33 C415.2 ; C417.2 122.81,66.23 v1(122.74,66.3) ; P801.K40 v1(131.48,22.48)
  BOTTOM w0.508: C735.2 49.64,16.06 C734.2
  BOTTOM w0.762: P707.1 48.87,15.29 C734.2
VDD_IF_LDO: length 2.9
  TOP w0.254: U702.5 57.63,14.69 58.1,15.16 58.1,16.32
  TOP w0.305: U702.7 56.66,16.06
  vias: v1(57.41,17.5) v1(58.47,18.72) v1(58.43,17.45) v1(58.94,18.08) v1(59.45,18.72) v1(59.45,17.51)
VDDA_1P8_1: length 8.1
  TOP w0.127: L306.1 36.39,34.2
  TOP w0.394: 36.78,34.2 35.77,34.2 T306.2 T310.2
  TOP w0.508: 36.78,34.2 37.21,34.2 C327.1 37.6,34.21 37.79,34.02 v1(38.57,34.02) v1(38.57,34.73) v1(38.57,35.44)
  BOTTOM w0.508: L341.2 38.57,36.81 v1(38.57,35.44) v1(38.57,34.73) v1(38.57,34.02)
VDDA_1P8_2: length 6.7
  TOP w0.127: L305.1 33.28,59.35
  TOP w0.394: 32.9,59.35 33.91,59.35 T305.2 T309.2
  TOP w0.508: 32.9,59.35 32.47,59.35 C322.1 32.05,59.34 31.93,59.22 v1(31.45,59.22) v1(31.45,59.93) v1(31.45,60.64)
  BOTTOM w0.394: 32.01,61.13 L340.2
  BOTTOM w0.508: L340.2 31.46,60.64 v1(31.45,60.64) v1(31.45,59.93) v1(31.45,59.22)
VDDA_CALPLL: length 17.7
  TOP w0.254: v2(33.24,43.58) U101.G4
  L7_SIG w0.203: 34.43,41.58 34.43,42.93 34.16,43.19 33.88,43.19 33.5,43.58 v2(33.24,43.58)
  L7_SIG w0.394: v1(31.89,33.19) 31.89,34.88 32.49,35.48 33.03,35.48 34.43,36.88 34.43,41.58
  BOTTOM w0.305: C615.1 33.62,44.07 33.24,43.69 v2(33.24,43.58)
  BOTTOM w0.508: E602.2 32.78,30.65 32.78,32.01 31.89,32.9 v1(31.89,33.19)
VDDA_CLK: length 4.7
  TOP w0.254: v2(38.84,41.18) U101.N1
  BOTTOM w0.305: 40.86,40.74 40.47,41.12 C617.1 38.89,41.12 v2(38.84,41.18) ; C616.1 41.03,40.76 E603.2
  BOTTOM w0.394: C616.1 40.86,40.74
VDDA_CLKSYNTH: length 23.2
  TOP w0.254: v2(33.24,45.18) U101.G6
  L3_PWR w0.127: v2(33.24,45.18) 33.66,44.76 34.2,44.76 34.42,44.53 34.42,41.33 36.06,39.68 36.42,39.68 36.97,39.14 39.99,39.14 41.54,40.69 47,40.69 v1(47.25,40.43)
  BOTTOM w0.305: v2(33.24,45.18) 33.23,45.18 C619.1 ; v1(47.25,40.43) 47.17,40.35 E604.2 46.08,40.36 C618.1
VDDA_DES: length 38.8
  TOP w0.254: U101.N9 v2(38.84,48.38) ; v2(39.64,48.38) U101.P9 v2(39.64,47.58)
  BOTTOM w0.305: C653.1 38.76,49.91 38.76,49.6 38.42,49.26 C654.1 38.42,48.8 v2(38.84,48.38) v2(39.64,48.38) 39.64,48.05 v2(39.64,47.58)
  BOTTOM w0.508: 39.64,48.05 39.71,48.13 48.95,48.13 52.71,44.37 55,44.37 59.73,39.64 59.73,38.32 61.55,36.5 61.73,36.5 62.6,35.63 C652.1 62.23,33.93 60.05,33.93 E613.2
VDDA_RXLO: length 17
  TOP w0.254: U101.C6 v2(30.04,45.18)
  L12_PWR w0.508: v3(25.66,43.99) 21.6,39.92 v1(20.96,39.92)
  BOTTOM w0.203: C621.1 28.46,45.18
  BOTTOM w0.305: v2(30.04,45.18) 27.52,45.18 27.2,45.5 26.45,45.5 C620.1
  BOTTOM w0.394: C620.1 26.17,45.51 25.79,45.13 25.79,44.12 v3(25.66,43.99)
  BOTTOM w0.508: v1(20.96,39.92) 20.71,40.18 20.71,40.5 20.29,40.92 17.76,40.92 E605.2
VDDA_RXSYNTH: length 25.6
  TOP w0.254: U101.G9 v2(34.04,47.58)
  L5_SIG w0.114: 34.39,45.3 33.57,46.12 33.57,47.11 v2(34.04,47.58)
  L5_SIG w0.127: 34.39,45.3 34.39,41.1
  L5_SIG w0.203: 43.4,40.98 41.83,40.98 39.99,39.14 37.02,39.14 36.44,39.72 35.77,39.72 34.39,41.1
  L5_SIG w0.305: v1(45.6,38.15) 45.6,38.63 45.81,38.83 45.81,39.75 44.57,40.98 43.4,40.98
  BOTTOM w0.305: v1(45.6,38.15) 45.6,37.64 45.87,37.37 C622.1 E606.2 ; C623.1 34.07,47.54 v2(34.04,47.58)
VDDA_RXTX: length 33.8
  TOP w0.203: v2(33.24,42.78) U101.F2
  L10_SIG w0.203: 34.03,41.45 33.66,41.82 33.66,42.07 33.24,42.49 v2(33.24,42.78) 33.29,42.72 33.56,42.72 33.88,42.39 34.16,42.39 34.42,42.13 34.42,41.82 34.05,41.45 34.03,41.45
  L10_SIG w0.394: v1(42.43,26.21) v1(41.67,26.21) 40.9,26.97 39.74,26.97 36.97,29.74 36.93,29.74 35.7,30.97 35.7,33.96 34.68,34.97 34.68,40.79 34.03,41.45
  BOTTOM w0.305: v2(33.24,42.78) 33.47,42.78 33.75,43.06 C610.1 35.26,43.06 C609.1
  BOTTOM w0.394: 48.27,26.97 C608.1 44.71,26.97 43.95,26.21 v1(42.43,26.21) v1(41.67,26.21)
VDDA_RXVCO: length 21.4
  TOP w0.254: U101.C7 v2(30.04,45.98)
  L12_PWR w0.394: v3(27.19,46.53) 26.42,46.53 24.9,45 24.66,45 v1(24.16,44.5)
  BOTTOM w0.305: v2(30.04,45.98) 29.52,45.98 29,46.49 C625.1 28.62,46.49 28.33,46.78 27.96,46.78 C624.1
  BOTTOM w0.394: v3(27.19,46.53) 27.58,46.92 C624.1 ; 11.44,42.97 11.57,43.1 23.12,43.1 24.01,43.99 24.01,44.35 v1(24.16,44.5)
VDDA_SER: length 31.6
  TOP w0.254: v2(39.64,46.78) U101.P8 v2(38.84,46.78) U101.N8
  BOTTOM w0.305: C613.1 39.96,46.78 v2(39.64,46.78) v2(38.84,46.78)
  BOTTOM w0.394: C612.1 40.2,45.56 C613.1
  BOTTOM w0.508: C612.1 40.47,45.69 40.48,45.69 46.16,45.69 46.24,45.77 47.63,45.77 48.61,44.8 48.61,44.54 51.36,41.79 53.9,41.79 56.88,38.8 C611.1 56.52,33.93 54.33,33.93 E601.2
VDDA_SNRXSYNTH: length 23.4
  TOP w0.254: U101.G7 v2(34.04,46.78)
  L12_PWR w0.127: 30.48,47.99 31,47.99 31.11,48.1 33.23,48.1 33.61,47.73 33.61,47.21 v2(34.04,46.78)
  L12_PWR w0.394: 30.48,47.99 29.91,47.99 29.35,48.56 27.11,48.56 25.59,50.08 22.68,50.08 v1(21.92,49.32)
  BOTTOM w0.305: v2(34.04,46.78) 34.11,46.71 C627.1
  BOTTOM w0.394: E608.2 18.61,52.09 C626.1 20.11,52.09 22.11,50.08 22.11,49.51 v1(21.92,49.32)
VDDA_SNRXVCO: length 19.6
  TOP w0.254: v2(30.04,43.58) U101.C4
  L12_PWR w0.203: 27.17,42.64 28.52,43.99 29.63,43.99 v2(30.04,43.58)
  L12_PWR w0.508: 27.17,42.64 27.17,41.34 27.19,41.32 27.19,41.31 27.31,41.19 27.31,39.04 v1(26.93,38.65)
  BOTTOM w0.203: C629.1 30.17,44.18 30.04,44.05 v2(30.04,43.58)
  BOTTOM w0.508: E609.2 22.56,29.57 C628.1 26.23,34.97 26.43,35.5 v1(26.93,38.65)
VDDA_TXLO: length 29.9
  TOP w0.254: v6(33.24,50.78) U101.F12
  L10_SIG w0.394: v5(34.03,50.71) 33.97,50.78 v6(33.24,50.78)
  L12_PWR w0.203: 29.09,53.51 30.64,51.96 31.66,51.96 33.05,50.57 33.89,50.57 v5(34.03,50.71)
  L12_PWR w0.394: 29.09,53.51 29.09,54.15 24.77,58.47 22.87,58.47 17.76,63.58 17,63.58 16.84,63.42 v1(15,63.42)
  BOTTOM w0.305: v5(34.03,50.71) 34.07,50.75 C635.1
  BOTTOM w0.394: v1(15,63.42) C634.1 13.34,62.78 E612.2
VDDA_TXSYNTH: length 30
  TOP w0.254: v6(33.24,47.58) U101.G8
  L10_SIG w0.127: v6(33.24,47.58) 32.85,47.97 29.81,47.97 29.6,48.18 29.6,48.56 29.44,48.72 28.78,48.72 28.74,48.76
  L10_SIG w0.254: v1(15.2,55.21) 15.3,55.31 19.33,55.31 20.58,56.56 22.11,56.56 22.36,56.31 25.16,56.31 28.08,53.39 v1(28.08,52.98) 27.82,52.73 27.82,50.46 27.57,50.2 27.57,49.16 27.97,48.76 28.74,48.76
  BOTTOM w0.305: C633.1 28.25,53.15 v1(28.08,52.98)
  BOTTOM w0.394: v1(15.2,55.21) 13.94,55.21 C632.1 13.73,55.16 E611.2
VDDA_TXVCO: length 32.5
  TOP w0.254: v6(33.24,49.18) U101.F11
  L5_SIG w0.203: 27.06,49.71 27.98,48.79 30.18,48.79 30.46,48.52 30.46,48.22 30.68,47.99 33.66,47.99 v5(34.04,48.38)
  L5_SIG w0.305: v6(33.24,49.18) 34.01,49.18 v5(34.04,49.21)
  L5_SIG w0.394: 27.06,49.71 25.46,49.71 22.3,52.87 22.3,56.12 19.72,58.69 16.11,58.69 v1(15,59.8)
  BOTTOM w0.305: C631.1 34.04,48.81 ; 34.04,48.81 v5(34.04,49.21) ; 34.04,48.81 34.04,48.38 v5(34.04,48.38)
  BOTTOM w0.394: v1(15,59.8) C630.1 ; C630.1 13.94,59.79 12.57,59.79 ; C630.1 12.58,59.8 12.57,59.79 ; E610.2 12.57,59.79
1P3_BUCK_OUT: length 25.4
  L8_SIG w0.394: v1(85.18,33.72) 84.4,32.94 77.23,32.94 75.41,31.12 75.41,20.1 v1(76.11,19.39) v1(76.87,19.39) v1(77.64,19.39)
  BOTTOM w0.394: v1(85.18,33.72) 85.59,33.31 R705.1
3P3V_CLK: length 43.2
  TOP w0.203: v1(119.82,32.83) 119.82,33.58 U404.6
  TOP w0.305: U405.14 v1(118.84,66.3)
  TOP w0.394: C424.2 v1(83.28,73.33) ; v1(83.22,74.83) C423.2 ; C436.2 v1(90.54,79.63) ; v1(83.2,69.75) 83.31,69.86 C425.2 ; C427.2 v1(89.04,67.53) ; C421.2 v1(83.24,77.83) ; C432.2 v1(95.34,73.83) ; C431.2 v1(95.34,72.33) ; v1(74.93,79.04) 74.91,79.05 C414.2 ; C433.2 v1(95.34,75.33) ; C426.2 86.04,67.63 85.94,67.54 v1(85.94,67.54) ; C437.2 v1(89.04,79.63) ; C422.2 v1(83.24,76.33) ; C428.2 v1(93.54,67.53) ; C429.2 v1(95.34,69.33) ; C438.2 v1(87.54,79.63) ; C430.2 v1(95.34,70.83) ; C435.2 v1(92.04,79.63) ; C434.2 v1(93.54,79.63) ; C439.2 v1(86.04,79.63)
  BOTTOM w0.203: U401.1 v1(93.54,67.53) ; U401.36 84.34,77.83 ; 94.41,70.83 94.41,70.83 U401.69 ; U401.51 92.04,78.53 ; U401.63 94.24,73.83 ; 89.04,68.45 89.04,68.45 U401.10 ; U401.16 86.04,68.45 ; U401.45 89.04,78.53
  BOTTOM w0.254: U401.42 87.54,79.63 v1(87.54,79.63) ; U401.20 83.82,69.83 83.8,69.81 83.72,69.81 83.66,69.75 v1(83.2,69.75) ; 84.34,77.83 v1(83.24,77.83) ; 94.41,70.83 v1(95.34,70.83) ; U401.30 v1(83.22,74.83) ; U401.66 v1(95.34,72.33) ; U401.60 v1(95.34,75.33) ; 86.04,68.45 86.04,67.63 85.94,67.54 v1(85.94,67.54) ; v1(95.34,69.33) U401.72 ; U401.54 v1(93.54,79.63) ; U401.39 v1(86.04,79.63) ; 92.04,78.53 v1(92.04,79.63) ; U401.33 v1(83.24,76.33) ; 89.04,78.53 v1(89.04,79.63) ; 94.24,73.83 v1(95.34,73.83) ; U401.27 v1(83.28,73.33) ; 89.04,68.45 v1(89.04,67.53) ; U401.48 v1(90.54,79.63)
  BOTTOM w0.305: U402.5 v1(74.93,79.04)
  BOTTOM w0.394: C416.2 v1(119.82,32.83) ; v1(93.54,79.63) 93.55,79.63 C420.1 ; v1(83.2,69.75) 82.98,69.53 R416.1 ; v1(118.84,66.3) 118.87,66.26 C418.2
  vias: v1(109.99,31.73) v1(109.99,30.97) v1(110.88,31.73) v1(110.88,30.97) v1(111.77,31.73) v1(111.77,30.97)
3P3V_VCO: length 65
  BOTTOM w0.305: 127.01,74.97 127.01,74.96 C738.2
  BOTTOM w0.394: v1(109.41,76.5) C405.2 Y402.6 Y403.4 Y401.6
  BOTTOM w0.508: E706.2 103.91,38.29 107.97,38.29 109.86,40.18 111.13,40.18 114.18,43.23 116.21,43.23 118.75,45.77 120.53,45.77 126.5,51.74 126.97,51.74 130.06,54.83 130.06,72.44 127.53,74.97 v1(126.23,74.97) v1(125.56,74.97) 125.56,74.13 124.82,73.39 124.35,72.91 R408.2
3P3VAUX: length 101.7
  TOP w0.305: v1(112.97,33.67) 113.21,33.43 R818.2 ; U801.8 C803.2 125.17,31.99 125.17,31.99 C804.1 127.52,31.96 v1(127.68,31.96) ; R820.2 v1(113.8,30.53) ; R822.2 v1(113.8,28.75) ; U601.10 v1(45.49,22.29) ; U601.17 U601.16
  TOP w0.635: U601.16 50.55,22.29 51.2,21.64 v7(51.2,20.37)
  L10_SIG w0.394: v7(51.2,20.37) 50.18,21.38 46.4,21.38 v1(45.49,22.29)
  L10_SIG w0.762: v1(112.97,33.67) 113.8,32.83 v1(113.8,30.53) v1(113.8,28.75) 113.8,21.51 106.05,13.76 61.6,13.76 59.19,16.18 57.03,16.18 52.84,20.37 v7(51.2,20.37)
  BOTTOM w0.394: C649.1 50.22,21.07 50.91,20.37 v7(51.2,20.37) 51.19,20.38 C648.1 ; P801.D32 v2(139.1,33.91)
ADP5054_EN: length 108.4
  TOP w0.305: R702.1 79.66,31.77 v1(79.68,31.76)
  L8_SIG w0.394: v2(140.3,73.57) 142.46,73.57 143.57,72.45 143.57,38.84 143.52,38.78 143.52,38.74 141.89,37.12 141.39,37.12 137.17,32.89 137.17,32.39 135.52,30.74 127.56,30.74 126.25,32.05 122.82,32.05 122.42,32.45 121.66,32.45 121.39,32.18 120.1,32.18 120.09,32.17 119.55,32.17 119.54,32.18 116.34,32.18 115.71,32.81 98.31,32.81 97.31,31.81 79.73,31.81 v1(79.68,31.76)
  BOTTOM w0.394: P801.D1 139.74,73.01 v2(140.3,73.57)
ADP5054_VREG: length 20.4
  TOP w0.394: R703.2 87.86,20.73 87.86,20.99 v1(88.25,21.38) 88.95,22.08 90.64,22.08 91.04,21.68 91.04,21.53 v1(91.07,21.5) 91.4,21.83 91.4,29.02 v1(89.62,30.8)
  BOTTOM w0.203: U701.45 89.25,29.98 89.03,30.2 ; U701.44 88.75,29.92 89.03,30.2 ; 89.03,30.2 v1(89.62,30.8) 89.7,30.87 C702.2
  BOTTOM w0.254: U701.18 v1(88.25,21.38) ; v1(91.07,21.5) 90.75,21.82 U701.13
AUXADC_0: length 66
  TOP w0.254: U101.E13 v6(31.64,51.58)
  L5_SIG w0.114: v6(31.64,51.58) 31.97,51.24 32.79,51.24 34.68,53.13 34.68,56.56 36.65,58.53 37.86,58.53 39.82,60.5 44.26,60.5 44.38,60.38 44.38,60.34 44.68,60.04 45.65,60.04 46.14,60.53 47.22,60.53 47.71,60.04 68.38,60.04 70.3,61.96 70.3,66.02 72.46,68.18 79.13,68.18 81.29,66.02 P501.3
  BOTTOM w0.203: C506.1 P501.3
AUXADC_1: length 88.3
  TOP w0.254: U101.C11 v6(30.04,49.98)
  L5_SIG w0.114: v6(30.04,49.98) 29.6,50.41 29.6,51.69 29.38,51.91 29.04,51.91 28.77,52.18 28.77,52.9 25.66,56.01 25.66,60.24 26.51,61.09 26.53,61.09 26.99,61.56 26.99,66.4 27.44,66.85 28.08,66.85 28.77,67.55 28.77,69.07 30.81,71.1 33.98,71.1 36.33,68.75 45.86,68.75 47,69.9 47.8,69.9 47.84,69.87 54.9,69.87 55.82,70.79 61.86,70.79 63.15,69.5 65.82,69.5 66.29,69.02 67.84,69.02 68.17,69.35 80.43,69.35 82.46,67.33 82.46,63.58 P501.4
  BOTTOM w0.203: C505.1 P501.4
AUXADC_2: length 64.2
  TOP w0.254: U101.C12 v6(30.04,50.78)
  L5_SIG w0.114: v6(30.04,50.78) 30.41,50.4 32.39,50.4 33.7,51.72 33.9,51.91 33.97,51.91 35.19,53.13 35.19,56.11 36.94,57.86 38.01,57.86 39.76,59.61 46.68,59.61 46.93,59.36 69.19,59.36 70.88,61.04 70.88,61.56 70.88,61.56 70.88,61.99 70.88,61.99 70.88,65.52 72.84,67.48 77.29,67.48 78.75,66.02 P501.5
  BOTTOM w0.203: 78.75,66.42 P501.5
AUXADC_3: length 64.8
  TOP w0.254: U101.D11 v6(30.84,49.98)
  L5_SIG w0.114: v6(30.84,49.98) 31.17,49.64 32.58,49.64 32.9,49.96 32.9,50.12 33.1,50.31 33.38,50.31 33.7,50.63 33.7,50.85 33.9,51.05 34.12,51.05 34.43,51.35 34.43,51.86 35.63,53.07 35.63,55.12 36.28,55.77 36.39,55.77 37.44,56.82 39.25,56.82 40.59,58.15 42.62,58.15 43.5,59.04 45.1,59.04 45.42,58.72 69.48,58.72 71.38,60.63 71.38,65.13 73.22,66.98 75.89,66.98 77.42,65.45 77.42,63.74 P501.6
  BOTTOM w0.203: 78.75,60.93 P501.6
BAL_TX1+: length 0.5
  TOP w0.127: L305.2 33.79,58.82
BAL_TX2+: length 0.7
  TOP w0.127: L306.2 35.88,34.73 T306.3
BAL_TX_OUT1: length 1
  TOP w0.203: T305.1 33.92,60.36 ; 33.92,60.94 R303.1
  TOP w0.394: 33.92,60.36 33.92,60.94
BAL_TX_OUT2: length 1
  TOP w0.203: C306.1 35.76,32.62 ; T306.1 35.76,33.19
  TOP w0.394: 35.75,33.01 35.75,33 ; 35.76,32.62 35.76,33.19
CLK+: length 7.5
  BOTTOM w0.203: 92.72,63.47 92.28,63.47 92.06,63.69 92.06,64.42 92.97,65.32 92.97,67.76 93.04,67.83 U401.2 ; 92.72,63.47 93.54,63.47 C402.2 ; 92.72,63.47 R406.1
CLK-: length 8.1
  BOTTOM w0.203: U401.3 92.54,67.83 92.61,67.76 92.61,65.47 91.7,64.56 91.7,63.55 92.13,63.12 92.72,63.12 ; R406.2 92.72,63.12 ; 92.72,63.12 93.54,63.12 C403.2
CLK_RESETB: length 109.6
  TOP w0.203: v1(120.18,35.62) 119.33,35.62 119.1,35.38 119.1,34.74 119.43,34.41 U404.5
  L7_SIG w0.114: v1(120.18,35.62) 120.18,35.45 120.91,34.72 125.36,34.72 127.64,37 135.24,37 137.37,39.14 137.37,39.18 137.64,39.45 137.69,39.45 138.87,40.64 138.87,41.25 142.25,44.62 142.25,59.61 141.94,59.92 137.82,59.92 137.68,59.77 134.72,59.77 132.09,62.4 127.39,62.4 125.23,64.56 117.61,64.56 114.94,67.23 94.75,67.23 92.92,69.06 v1(83.45,69.06)
  BOTTOM w0.203: v1(83.45,69.06) 83.72,69.33 U401.19
  BOTTOM w0.394: v1(83.45,69.06) 82.93,68.54 R416.2
CLK_SYSREF_REQUEST: length 32.4
  TOP w0.203: U405.13 v1(119.49,69.23)
  L7_SIG w0.114: v1(119.49,69.23) 117.04,71.67 102.75,71.67 99.96,74.47 98.31,74.47 96.53,76.24 v1(96.53,77.8)
  BOTTOM w0.254: U401.57 94.92,76.83 95.57,76.83 v1(96.53,77.8) ; R417.2 97.17,77.8
  BOTTOM w0.394: 97.17,77.8 v1(96.53,77.8)
COMP_OUT: length 4.9
  BOTTOM w0.203: R411.1 110.59,73.18 111.38,73.96 Y402.5 Y401.5
DEV_CLK_IN+: length 66.7
  BOTTOM w0.203: 81.75,72.41 R425.1 ; 81.75,72.41 81.24,72.41 arc(73.86,71.88) 66.64,70.3 arc(58.87,68.59) 50.94,67.97 50.94,67.97 arc(47.52,66.56) 46.11,63.14 46.11,58.34 arc(44.94,55.52) 42.12,54.35 38.29,54.35 arc(35.41,53.73) 33.1,51.9 arc(32.44,50.7) 32.21,49.34 32.21,48.56 ; 81.75,72.41 83.63,72.41 83.72,72.33 U401.25 ; 32.21,48.56 32.21,48.29 arc(32.24,48.12) C502.1 ; 32.21,48.56 R501.2
DEV_CLK_IN-: length 67.3
  BOTTOM w0.203: 81.75,72.77 83.62,72.77 83.68,72.83 U401.26 ; 81.75,72.77 81.24,72.77 arc(73.81,72.23) 66.54,70.64 arc(58.82,68.94) 50.94,68.32 arc(47.27,66.81) 45.75,63.14 45.75,58.34 arc(44.69,55.77) 42.12,54.7 38.29,54.7 arc(35.26,54.05) 32.83,52.13 arc(32.1,50.82) 31.85,49.34 31.85,48.56 ; 81.75,72.77 R425.2 ; R501.1 31.85,48.56 ; 31.85,48.56 31.85,48.29 arc(31.81,48.12) C501.1
DIR_CLK+: length 4.6
  BOTTOM w0.203: 96.02,63.47 95.2,63.47 C402.1 ; 96.02,63.47 96.85,63.47 R403.2 97.49,64.12 97.99,64.12 98.43,64.56 T401.1 ; 96.02,63.47 R405.1
DIR_CLK-: length 4.6
  BOTTOM w0.203: C403.1 95.2,63.12 96.02,63.12 ; R405.2 96.02,63.12 ; 96.02,63.12 96.83,63.12 R404.1 97.46,62.49 98.01,62.49 98.48,62.02 T401.3
EPROM_A0: length 115.9
  TOP w0.203: v1(46.87,20.24) 47.52,20.89 U601.11
  TOP w0.305: R818.1 R819.2 115.77,32.79 116.61,31.95 U801.1 118.85,31.95 v1(119.89,30.91)
  L8_SIG w0.114: v1(119.89,30.91) 119.39,30.91 114.31,25.83 102.5,25.83 94.18,17.51 81.86,17.51 80.78,16.43 57.67,16.43 52.34,21.76 48.39,21.76 v1(46.87,20.24)
  L10_SIG w0.114: v2(141.64,30.1) 139.72,30.1 137.37,27.75 137.37,27.55 136.53,26.72 124.08,26.72 v1(119.89,30.91)
  BOTTOM w0.394: P801.C34 v2(141.64,30.1)
EPROM_A1: length 115.9
  TOP w0.203: U601.13 48.52,20.62 v1(48.14,20.24)
  TOP w0.305: v1(118.85,31.09) 118.64,31.3 U801.2 116.46,31.3 116.11,31.65 R821.2 R820.1
  L8_SIG w0.114: v1(48.14,20.24) 49.03,21.13 52.21,21.13 57.61,15.73 97.23,15.73 105.8,24.3 114.31,24.3 120.53,30.53 120.53,31.03 120.02,31.54 119.26,31.54 118.85,31.13 v1(118.85,31.09)
  L10_SIG w0.114: v2(140.37,28.83) 137.5,25.95 123.98,25.95 v1(118.85,31.09)
  BOTTOM w0.394: P801.D35 v2(140.37,28.83)
FMC_CLK_RESETB: length 24
  TOP w0.305: v2(140.37,41.53) 138.57,39.73 138.57,37.52 136.91,35.86 130.82,35.86 130.37,35.41 123.77,35.41 122.77,34.41 U404.2
  BOTTOM w0.394: v2(140.37,41.53) P801.D26
FMC_SYSREF_REQUEST: length 49
  TOP w0.203: U405.2 v1(119.49,63.29)
  L8_SIG w0.114: v2(140.37,38.99) 139.35,40.01 139.35,46.94 140.22,47.8 141.21,47.8 141.21,48.04 141.48,48.31 141.87,48.31 141.9,48.28 142.25,48.64 142.25,57.07 140.65,58.67 132.77,58.67 129.4,62.05 126.86,62.05 125.84,61.03 121.74,61.03 v1(119.49,63.29)
  BOTTOM w0.394: v2(140.37,38.99) P801.D27
FMCA_SCL: length 107.4
  TOP w0.203: U601.15 49.52,20.76 v1(50.05,20.24)
  TOP w0.305: U801.6 122.19,30.65 v1(121.8,31.03)
  L8_SIG w0.114: v1(50.05,20.24) 51.57,18.72 53.73,18.72 57.41,15.03 108.21,15.03 114.25,21.07 114.25,23.22 120.91,29.89 120.91,30.15 v1(121.8,31.03)
  L10_SIG w0.114: v1(121.8,31.03) 122.31,31.03 122.68,31.41 130.69,31.41 133.87,34.59 141.06,34.59 v2(141.64,35.18)
  BOTTOM w0.394: v2(141.64,35.18) P801.C30
FMCA_SDA: length 110
  TOP w0.203: U601.14 v1(49.02,20.24)
  TOP w0.305: v1(121.82,30) U801.5
  L8_SIG w0.114: v1(121.82,30) 121.82,29.91 114.75,22.84 114.75,20.43 108.59,14.27 53.6,14.27 49.02,18.85 v1(49.02,20.24)
  L10_SIG w0.114: v2(141.64,33.91) 141.64,33.86 137.3,29.51 127.52,29.51 126.88,28.88 125.1,28.88 123.98,30 v1(121.82,30)
  BOTTOM w0.394: v2(141.64,33.91) P801.C31
FMCA_VADJ: length 13.2
  TOP w0.762: 131.44,19.44 129.45,19.44 TP812.1 ; 131.44,19.44 131.45,19.43 C732.1 ; 131.44,19.44 R738.1
  L12_PWR w0.508: TP812.1 128.3,21.61 ; TP812.1 128.3,19.57 ; TP812.1 127.28,20.59 ; TP812.1 129.31,20.59
  BOTTOM w0.394: P801.H40 v2(134.02,23.75) ; P801.F40 v2(137.83,22.48) ; P801.E39 v2(139.1,23.75) ; P801.G39 v2(136.56,23.75)
FMCA_VCC_3P3V: length 7.7
  L12_PWR w0.508: 127.36,23.89 TP816.1 ; TP816.1 128.37,24.91 ; TP816.1 129.39,23.89 ; TP816.1 128.37,22.87
  BOTTOM w0.394: P801.C39 v2(141.64,23.75) ; P801.D38 v2(140.37,25.02) ; P801.D36 v2(140.37,27.56) ; P801.D40 v2(140.37,22.48)
FMCA_VCC_12P0V: length 5.9
  TOP w0.508: 120.28,26.59 TP815.1 ; TP815.1 121.29,25.57 ; TP815.1 121.29,27.61 ; TP815.1 122.31,26.59
  BOTTOM w0.394: P801.C37 v2(141.64,26.29) ; P801.C35 v2(141.64,28.83)
FPGA_AUX_CLK+: length 49.2
  TOP w0.203: C805.1 140.22,70.09 139.16,71.14 138.97,71.14 137.82,72.28 134.97,72.28 134.18,73.07 131.58,73.07 130.43,74.23 126.7,74.23 126.5,74.02 122.88,74.02 121.93,74.98 102.3,74.98 v1(102.28,75)
  BOTTOM w0.203: 99.07,74.76 95.1,74.76 95.04,74.83 U401.61 ; 99.07,74.76 R429.1 ; 99.07,74.76 102.05,74.76 v1(102.28,75)
FPGA_AUX_CLK-: length 49.2
  TOP w0.203: v1(102.28,74.18) 102.72,74.62 121.78,74.62 122.73,73.67 126.65,73.67 126.85,73.87 130.28,73.87 131.43,72.72 134.04,72.72 134.82,71.93 137.68,71.93 138.82,70.79 139.02,70.79 139.86,69.94 139.86,69.76 139.71,69.6 139.71,69.45 139.58,69.33 C806.1
  BOTTOM w0.203: U401.62 95.04,74.33 95.11,74.4 99.07,74.4 ; R429.2 99.07,74.4 ; 99.07,74.4 99.07,74.41 99.68,74.41 102.06,74.41 v1(102.28,74.18)
FPGA_REF_CLK+: length 82
  TOP w0.203: C801.2 143.27,50.36 143.47,50.56 144.55,50.56 145.25,51.27 145.25,60.39 146.14,61.27 146.14,62.39 145.93,62.59 145.93,72.37 141.23,77.07 133.8,77.07 132.22,78.66 103.51,78.66 98.35,73.49 v1(97.65,73.49) 97.65,73.47
  BOTTOM w0.203: 96.63,73.26 95.11,73.26 95.04,73.33 U401.64 ; 96.63,73.26 R422.1 ; 96.63,73.26 97.41,73.26 v1(97.65,73.49)
FPGA_REF_CLK-: length 82
  TOP w0.203: v1(97.65,72.68) 98.11,73.14 98.49,73.14 103.66,78.3 132.07,78.3 133.66,76.72 141.09,76.72 145.58,72.23 145.58,62.45 145.78,62.24 145.78,61.42 144.89,60.54 144.89,51.41 144.4,50.92 143.32,50.92 142.91,50.51 142.91,49.44 142.76,49.28 142.76,49.2 142.57,49.01 C802.2
  BOTTOM w0.203: R422.2 96.63,72.9 ; 96.63,72.9 97.43,72.9 v1(97.65,72.68) ; 96.63,72.9 95.11,72.9 95.04,72.83 U401.65
FPGA_SYSREF+: length 98.5
  L7_SIG w0.091: v1(98.79,76.49) 107.65,76.49 108.53,75.61 117.46,75.61 122.8,70.28 131.07,70.28 133.66,67.69 137.07,67.69 142.23,62.53 143.77,62.53 145.3,61.01 145.3,45.39 146.06,44.62 146.06,42.25 144.8,41 144.46,41 143.65,40.18 143.65,33.57 142,31.92 139.39,31.92 136.06,28.59 136.06,27.96 136.45,27.56 v2(136.56,27.56)
  BOTTOM w0.203: 96.72,76.26 97.33,76.26 98.56,76.26 v1(98.79,76.49) ; 96.72,76.26 95.16,76.26 95.09,76.33 94.47,76.33 U401.58 ; 96.72,76.26 R423.2
  BOTTOM w0.394: P801.G36 v2(136.56,27.56)
FPGA_SYSREF-: length 98.5
  L7_SIG w0.091: v1(98.79,75.68) 99.35,76.24 107.54,76.24 108.43,75.36 117.36,75.36 122.69,70.02 130.97,70.02 133.55,67.44 136.96,67.44 142.12,62.28 143.67,62.28 145.04,60.9 145.04,45.28 145.81,44.52 145.81,42.36 144.7,41.25 144.36,41.25 143.39,40.28 143.39,33.68 141.89,32.18 139.28,32.18 135.8,28.7 135.8,27.76 135.6,27.56 v2(135.29,27.56)
  BOTTOM w0.203: 96.72,75.9 97.33,75.9 98.56,75.91 98.57,75.91 v1(98.79,75.68) ; 96.72,75.9 95.16,75.9 95.09,75.83 U401.59 ; 96.72,75.9 R423.1
  BOTTOM w0.394: P801.G37 v2(135.29,27.56)
GP_INTERRUPT: length 113.4
  TOP w0.254: U101.J5 v6(35.64,45.18)
  TOP w0.394: TP803.1 129.71,59.98 134.18,59.98 134.25,59.91 R803.1
  L7_SIG w0.114: TP803.1 127.72,58.1 122.37,52.75 103.64,52.75 99.83,56.56 89.69,56.56 87.64,54.51 87.64,53.91 86.48,52.75 85.73,52.75 84.89,51.9 84.89,49.87 83.18,48.16 82.8,48.16 78.22,43.58 78.19,43.58 77.88,43.28 77.88,43.25 77.19,42.55 55.15,42.55 54.93,42.78 52.53,42.78 51.98,43.33 46.77,43.33 45.26,44.84 40.14,44.84 40.14,44.84 38.7,44.84 38.37,45.16 38.37,45.32 38.18,45.51 37.9,45.51 37.7,45.32 37.7,45.16 37.38,44.84 35.97,44.84 v6(35.64,45.18)
GPIO_0: length 110.5
  TOP w0.254: U101.K8 v6(36.44,47.58)
  TOP w0.305: R513.2 R517.1 96.26,54.23 P502.2
  L7_SIG w0.114: P502.2 100.15,50.34 126.81,50.34 126.95,50.2 129.07,50.2 129.34,50.46 129.76,50.46 130.01,50.21 133.82,50.21 v2(134.02,50.42)
  L8_SIG w0.114: P502.2 96.4,54.91 94.88,56.43 82.05,56.43 81.03,55.42 80.05,55.42 80.04,55.41 79.62,55.41 79.61,55.42 72.4,55.42 66.3,49.32 51.19,49.32 50.03,48.16 47.78,48.16 46.91,47.29 45.63,47.29 45.16,46.83 44.74,46.83 44.65,46.92 43.41,46.92 43.15,46.66 40.31,46.66 39.77,47.19 37.08,47.19 36.69,47.58 v6(36.44,47.58)
  BOTTOM w0.394: v2(134.02,50.42) P801.H19
GPIO_1: length 125.5
  TOP w0.254: U101.J8 v6(35.64,47.58)
  TOP w0.305: 98.62,52.88 98.62,52.37 R516.1 ; 98.62,52.88 R512.2 ; 98.62,52.88 95.2,52.88 P502.3
  L7_SIG w0.114: P502.3 96.09,49.31 117.63,49.31 117.64,49.32 130.91,49.32 131.55,48.69 132.56,48.69 132.56,48.69 132.95,48.69 132.95,48.69 133.56,48.69 v2(134.02,49.15)
  L8_SIG w0.114: v6(35.64,47.58) 35.23,47.16 34.75,47.16 34.43,46.84 34.43,43.74 36.1,42.06 36.1,41.84 36.3,41.64 36.78,41.64 37.6,40.81 40.14,40.81 42.05,38.9 43.45,38.9 45.22,37.13 54.11,37.13 54.49,37.51 58.56,37.51 59.32,38.27 85.86,38.27 90.56,42.97 90.56,43.48 91.77,44.69 91.77,48.24 93.86,50.34 P502.3
  BOTTOM w0.394: v2(134.02,49.15) P801.H20
GPIO_2: length 123.6
  TOP w0.254: U101.J7 v6(34.84,45.98)
  TOP w0.305: P502.4 93.52,54.43 R515.1 R511.2
  L7_SIG w0.114: v2(136.56,50.42) 135.88,51.1 131.2,51.1 130.66,51.64 130.21,51.64 129.81,51.23 124.05,51.23 123.76,50.94 102.54,50.94 98.28,55.2 94.97,55.2 P502.4
  L8_SIG w0.114: v6(34.84,45.98) 34.68,45.82 34.68,43.99 36.33,42.34 36.71,42.34 37.41,41.64 39.95,41.64 41.41,40.18 46.49,40.18 47.77,38.9 53.6,38.9 54.54,39.84 84.89,39.84 88.04,43 88.04,43.5 90.99,46.46 90.99,49 92.47,50.47 92.47,52.69 P502.4
  BOTTOM w0.394: v2(136.56,50.42) P801.G18
GPIO_3: length 119.7
  TOP w0.254: U101.K7 v6(36.44,46.78)
  TOP w0.305: R514.1 91.51,49.32 R510.2
  TOP w0.394: R514.1 91.46,51.41 P502.5
  L7_SIG w0.114: v2(136.56,49.15) 134.83,47.42 134.22,47.42 134.22,47.42 133.83,47.42 133.83,47.42 119.01,47.42 118.68,47.09 116.16,47.09 115.72,47.53 95.33,47.53 94,48.87 94,48.9 93.69,49.2 93.67,49.2 P502.5
  L8_SIG w0.114: v6(36.44,46.78) 36.44,45.75 35.97,45.28 35.97,45.04 35.78,44.84 35.63,44.84 35.3,44.52 35.3,44.24 35.63,43.91 35.78,43.91 36.08,43.61 36.08,43.46 36.43,43.11 36.58,43.11 36.9,42.79 36.9,42.64 37.2,42.34 40.01,42.34 41.28,41.07 48.26,41.07 48.77,40.57 52.21,40.57 52.33,40.69 62.33,40.69 62.33,40.68 83.07,40.68 83.37,40.99 83.37,41.25 89.23,47.1 89.23,49.13 91.32,51.23 P502.5
  BOTTOM w0.394: v2(136.56,49.15) P801.G19
GPIO_3P3_0: length 59.1
  TOP w0.254: U101.C1 29.49,40.63 v6(29.35,40.63)
  L8_SIG w0.114: P503.5 64.02,66.09 61.48,68.63 50.05,68.63 49.67,68.25 48.78,68.25 48.52,68.5 46.49,68.5 40.65,62.66 40.65,61.26 39.13,59.74 38.81,59.74 33.54,54.46 33.54,52.19 31.66,50.31 31.5,50.31 31.3,50.12 31.3,49.92 30.09,48.71 29.9,48.71 29.7,48.52 29.7,48.36 29.4,48.05 29.39,48.05 29.38,48.04 29.23,48.04 28.79,47.6 28.79,44.07 28.46,43.74 28.46,41.93 28.85,41.53 28.85,41.02 29.24,40.63 v6(29.35,40.63)
  BOTTOM w0.203: P503.5 64.02,66.37
GPIO_3P3_1: length 52.3
  TOP w0.254: U101.C2 v6(30.04,41.98)
  L8_SIG w0.114: v6(30.04,41.98) 29.65,42.36 29.65,47.72 29.97,48.04 30.18,48.04 30.5,48.36 30.5,48.52 30.7,48.71 30.89,48.71 31.3,49.12 31.3,49.32 31.5,49.51 31.69,49.51 32.04,49.86 32.04,50.11 34.05,52.12 34.05,53.64 36.3,55.89 36.55,55.89 37.47,56.82 39.51,56.82 40.65,57.96 40.65,59.23 43.06,61.64 43.06,63.67 44.97,65.58 45.86,65.58 47.51,67.23 50.3,67.23 50.81,67.74 56.14,67.74 57.41,66.47 59.95,66.47 P503.7
  BOTTOM w0.203: P503.7 61.48,66.37
GPIO_3P3_2: length 43
  TOP w0.254: U101.F1 v6(32.44,41.18)
  L8_SIG w0.114: v6(32.44,41.18) 32.1,41.51 32.1,43.72 32.3,43.91 32.45,43.91 32.85,44.31 32.85,46.86 32.9,46.91 32.9,46.92 33.23,47.24 33.38,47.24 33.57,47.44 33.57,47.66 33.95,48.04 34.18,48.04 34.37,48.24 34.37,48.39 34.78,48.79 35.04,48.79 35.3,49.05 35.3,49.32 35.5,49.51 35.76,49.51 36.1,49.85 36.1,50.12 36.3,50.31 36.56,50.31 36.84,50.6 36.84,52.12 37.44,52.72 40.12,52.72 40.47,52.37 43.44,52.37 45.35,54.28 49.84,54.28 57.67,62.1 57.67,63.67 P503.9
GPIO_3P3_3: length 44.8
  TOP w0.254: v6(31.2,41.01) 31.2,41.54 U101.D1
  L8_SIG w0.114: P503.11 55.13,66.21 50.3,66.21 45.98,61.9 45.98,60.75 40.24,55.01 36.98,55.01 36.7,54.74 36.41,54.74 34.5,52.83 34.5,51.56 33.99,51.05 33.9,51.05 33.7,50.85 33.7,50.76 33.25,50.31 33.1,50.31 32.9,50.12 32.9,49.96 31.66,48.71 31.5,48.71 31.3,48.52 31.3,48.36 30.98,48.04 30.83,48.04 30.43,47.64 30.43,41.79 v6(31.2,41.01)
  BOTTOM w0.203: P503.11 C525.1
GPIO_3P3_4: length 40.6
  TOP w0.254: U101.E1 v6(31.64,41.18)
  L8_SIG w0.114: v6(31.64,41.18) 31.25,41.56 31.25,43.66 31.5,43.91 31.72,43.91 32.05,44.24 32.05,46.95 33.14,48.04 33.38,48.04 33.57,48.24 33.57,48.6 33.82,48.84 34.15,48.84 34.37,49.07 34.37,49.27 34.71,49.6 34.96,49.6 35.3,49.94 35.3,50.12 35.5,50.31 35.67,50.31 35.97,50.62 35.97,52.65 37.35,54.02 42.94,54.02 44.46,55.55 46.75,55.55 52.59,61.39 52.59,63.67 P503.13
  BOTTOM w0.203: P503.13 C526.1
GPIO_3P3_5: length 35
  TOP w0.254: U101.D5 v6(30.84,44.38)
  L8_SIG w0.114: P503.15 48.65,62.28 48.65,60.93 44.82,57.1 44.06,57.1 43.75,56.8 43.75,56.33 41.95,54.53 36.98,54.53 35.3,52.85 35.3,50.76 34.98,50.44 34.65,50.44 33.57,49.36 33.57,49.04 33.38,48.84 33.05,48.84 32.77,48.56 32.77,48.24 32.58,48.04 32.25,48.04 31.23,47.02 31.23,44.77 v6(30.84,44.38)
  BOTTOM w0.203: P503.15 C527.1
GPIO_3P3_6: length 56.1
  TOP w0.254: U101.E14 v6(31.64,52.38)
  L5_SIG w0.114: P503.2 67.95,63.55 63.38,63.55 62.75,62.91 62.75,62.07 62.41,61.73 62.41,61.68 61.99,61.26 58.18,61.26 57.54,61.9 57.54,65.39 56.84,66.09 49.36,66.09 49.36,66.08 48.16,66.08 48.09,66.15 46.68,66.15 46.49,65.96 46.11,65.96 46.1,65.96 45.68,65.96 45.67,65.96 39.17,65.96 34.43,61.22 34.43,60.63 32.97,59.17 32.97,57.46 32.3,56.78 32.23,56.78 31.7,56.24 31.7,55.5 32.58,54.62 32.58,52.86 32.43,52.71 32.3,52.71 31.96,52.38 v6(31.64,52.38)
  BOTTOM w0.203: P503.2 C528.1
GPIO_3P3_7: length 56.9
  TOP w0.254: U101.D12 v6(30.84,50.78)
  L8_SIG w0.114: v6(30.84,50.78) 31.29,51.23 31.77,51.23 31.97,51.44 31.97,51.59 32.42,52.04 32.58,52.04 32.85,52.31 32.85,54.94 32.75,55.04 32.75,55.47 33.05,55.77 33.06,55.77 33.39,56.1 33.4,56.1 33.7,56.4 33.7,56.41 34.71,57.42 34.71,58.28 39.89,63.46 39.89,64.94 44.71,69.77 53.98,69.77 55.13,70.91 61.99,70.91 66.43,66.47 66.68,66.47 67.83,65.32 67.83,63.67 P503.4
  BOTTOM w0.203: P503.4 66.56,60.65
GPIO_3P3_8: length 43.6
  TOP w0.254: U101.D13 v6(30.84,51.58)
  L5_SIG w0.114: P503.6 64.02,61.64 63,60.63 49.03,60.63 48.52,61.13 38.05,61.13 37.21,60.3 36.7,60.3 34.3,57.9 34.3,53.23 33.02,51.95 31.21,51.95 v6(30.84,51.58)
  BOTTOM w0.203: P503.6 64.02,60.65
GPIO_3P3_9: length 62
  TOP w0.254: U101.C13 v6(30.04,51.58)
  L5_SIG w0.114: P503.8 61.48,63.04 62.62,64.18 62.62,65.45 59.83,68.25 48.78,68.25 47.97,67.44 40.13,67.44 39.52,68.06 36.27,68.06 33.85,70.47 30.87,70.47 29.25,68.85 29.25,67.26 28.42,66.43 27.82,66.43 27.49,66.1 27.49,60.93 27.81,60.6 27.81,58.71 28.97,57.55 28.97,53.19 30.04,52.12 v6(30.04,51.58)
  BOTTOM w0.203: P503.8 61.48,60.65
GPIO_3P3_10: length 54.5
  TOP w0.254: U101.D14 v6(30.84,52.38)
  L5_SIG w0.114: v6(30.84,52.38) 30.42,52.38 29.34,53.46 29.34,58.76 29.68,59.1 29.68,59.81 28.2,61.29 28.2,65.29 30.46,67.55 38.93,67.55 39.7,66.79 45.48,66.79 45.68,66.98 48.8,66.98 48.93,67.11 50.29,67.11 50.89,66.51 59.15,66.51 60.21,65.45 60.21,63.67 P503.10
  BOTTOM w0.203: P503.10 C532.1
GPIO_3P3_11: length 32.7
  TOP w0.254: U101.F14 v6(32.44,52.38)
  L5_SIG w0.114: P503.12 55.13,63.67 47.57,63.67 47.28,63.38 40.23,63.38 38.74,61.9 37.79,61.9 36.9,61.01 36.2,61.01 33.8,58.61 33.8,53.68 32.85,52.73 32.85,52.63 32.59,52.38 v6(32.44,52.38)
GPIO_4: length 119.4
  TOP w0.254: U101.K6 v6(36.44,45.18)
  TOP w0.305: P502.6 91.29,54.11 R524.1
  L7_SIG w0.114: P502.6 90.18,52.94 90.18,50.47 94.88,45.77 113.42,45.77 113.72,46.07 117.69,46.07 118.31,45.45 130.47,45.45 133.12,42.8 v2(134.02,42.8)
  L8_SIG w0.114: P502.6 90.12,52.88 90.12,50.66 88.45,49 88.45,48.46 88.15,48.16 87.62,48.16 83.72,44.26 62.93,44.26 61.22,42.55 55.55,42.55 55.44,42.66 54.18,42.66 53.48,41.96 49.67,41.96 49.36,41.65 41.47,41.65 39.87,43.24 38.98,43.24 37.1,43.24 36.9,43.44 36.9,43.59 36.58,43.91 36.41,43.91 36.1,44.22 36.1,44.52 36.44,44.86 v6(36.44,45.18)
  BOTTOM w0.394: v2(134.02,42.8) P801.H25
GPIO_5: length 112.3
  TOP w0.254: U101.K5 v6(36.44,44.38)
  TOP w0.305: R522.1 89.04,51.29 P502.7
  L7_SIG w0.114: P502.7 88.78,48.94 90.56,47.16 90.56,46.53 93.48,43.61 107.23,43.61 107.24,43.61 107.66,43.61 107.67,43.61 117.69,43.61 117.83,43.46 118.26,43.46 118.93,44.14 122.41,44.14 122.69,43.86 131.19,43.86 133.53,41.53 v2(134.02,41.53)
  L8_SIG w0.097: 39.51,43.99 39.89,43.99
  L8_SIG w0.114: 39.89,43.99 40.78,43.1 49.67,43.1 49.92,43.35 53.6,43.35 54.3,44.05 59.88,44.05 61.42,45.58 82.25,45.58 84.46,47.8 85.35,47.8 88.78,51.23 P502.7 ; 39.51,43.99 37.15,43.99 36.76,44.38 v6(36.44,44.38)
  BOTTOM w0.394: v2(134.02,41.53) P801.H26
GPIO_6: length 120.8
  TOP w0.254: U101.L5 v6(37.24,44.38)
  TOP w0.305: P502.8 88.82,54.12 R523.1
  L7_SIG w0.114: v2(141.64,45.34) 141.11,45.87 141.11,47.76 137.03,51.84 137.03,51.88 136.55,52.36 129.29,52.36 128.92,51.99 102.88,51.99 98.94,55.93 90.62,55.93 P502.8
  L8_SIG w0.114: P502.8 87.64,52.94 87.64,50.97 86.21,49.55 86.21,49.31 86.1,49.2 82.81,49.2 82.81,49.19 82.65,49.19 80.16,46.71 80.16,46.59 79.66,46.09 60.4,46.09 59.77,45.45 57.85,45.45 56.96,44.56 55.32,44.56 55.19,44.68 49.85,44.68 49.28,44.12 40.52,44.12 39.89,44.75 37.61,44.75 v6(37.24,44.38)
  BOTTOM w0.394: v2(141.64,45.34) P801.C22
GPIO_7: length 119.8
  TOP w0.254: U101.L6 v6(37.24,45.18)
  TOP w0.305: P502.9 86.65,51.14 R519.1
  L7_SIG w0.114: v2(140.37,45.34) 140.37,44.46 137.99,42.08 135.65,42.08 134.49,40.93 132.07,40.93 131.31,41.69 130.7,41.69 130.64,41.63 127.85,41.63 127.14,42.34 121.95,42.34 121.57,41.96 120.06,41.96 119.61,42.41 113.74,42.41 113.42,42.08 93.1,42.08 91.07,44.12 90.43,44.12 89.54,45 89.54,45.64 86.24,48.94 P502.9
  L8_SIG w0.114: v6(37.24,45.18) 37.7,45.64 38.7,45.64 39.76,45.64 40.65,44.75 47.18,44.75 47.21,44.72 48.24,44.72 49.6,46.08 59.38,46.08 60.72,47.42 77.61,47.42 79.76,49.57 79.85,49.57 80.15,49.87 80.15,49.96 80.53,50.34 85.04,50.34 P502.9
  BOTTOM w0.394: P801.C23 v2(140.37,45.34)
GPIO_8: length 146.8
  TOP w0.254: U101.L12 v6(37.24,50.78)
  TOP w0.305: P502.10 86.23,54.1 86.23,56.32 R520.1
  L5_SIG w0.091: P502.10 86.24,55.32 85.93,55.64 85.93,55.89 85.97,55.93 97.29,55.93 99.2,54.02 102.88,54.02 103.13,53.77 123.86,53.77 124.11,53.51 129.95,53.51 131.22,52.24 136.81,52.24 138.81,50.25 138.81,42.57 138.5,42.26 135.96,42.26 135.77,42.45 135.77,43.14 135.64,43.27 135.03,43.27 134.77,43.01 134.77,42.14 134.65,42.01 132.24,42.01 132.12,42.14 132.12,44.42 132.24,44.55 133.37,44.55 133.5,44.42 133.5,43.61 133.63,43.48 134.37,43.48 134.5,43.61 134.5,44.42 134.62,44.55 135.82,44.55 135.94,44.42 135.94,43.74 136.07,43.62 137.23,43.62 137.35,43.49 137.35,42.93 137.23,42.8 v2(136.56,42.8)
  L10_SIG w0.091: v6(37.24,50.78) 37.63,51.17 37.63,51.75 37.05,52.34 37.05,53.49 37.96,54.4 44.46,54.4 46.16,52.7 70.11,52.7 73.44,49.37 79.28,49.37 79.32,49.33 79.95,49.33 79.99,49.37 83.34,49.37 85.04,51.06 85.04,52.88 P502.10
  BOTTOM w0.203: v2(136.56,42.8) P801.G25
GPIO_9: length 117.5
  TOP w0.254: U101.K12 v6(36.44,50.78)
  L5_SIG w0.091: P502.11 83.7,52.37 84.05,52.73 84.27,52.73 84.82,52.18 84.82,50.86 85.72,49.96 115.05,49.96 115.62,50.53 124.52,50.53 127.92,47.13 134.18,47.13 134.5,46.8 134.5,46 134.4,45.9 134.24,45.9 134.02,46.12 v2(134.02,46.61)
  L10_SIG w0.091: P502.11 83.83,51.55 83.95,51.67 83.95,52.56 83.83,52.69 72.87,52.69 68.37,57.2 41.43,57.2 40.57,58.06 37.05,58.06 35.66,56.68 35.66,52.1 35.76,52.01 35.85,52.01 36.08,51.78 36.08,51.13 v6(36.44,50.78)
  BOTTOM w0.203: v2(134.02,46.61) P801.H22
GPIO_10: length 117.5
  TOP w0.254: U101.J12 v6(35.64,50.78)
  L5_SIG w0.091: v2(134.02,45.34) 134.33,45.65 134.51,45.65 134.76,45.89 134.76,46.91 134.28,47.38 128.03,47.38 124.63,50.79 115.52,50.79 114.94,50.21 85.83,50.21 85.07,50.97 85.07,52.29 84.38,52.98 84.12,52.98 83.7,53.4 P502.12
  L10_SIG w0.091: P502.12 83.7,53.03 83.61,52.94 72.98,52.94 68.47,57.45 41.54,57.45 40.67,58.31 36.94,58.31 35.41,56.78 35.41,51.87 35.31,51.77 35.31,51.1 v6(35.64,50.78)
  BOTTOM w0.203: v2(134.02,45.34) P801.H23
GPIO_11: length 117.9
  TOP w0.254: U101.H12 v6(34.84,50.78)
  L5_SIG w0.091: P502.13 81.16,52.46 81.39,52.69 81.84,52.69 82.59,53.45 82.59,54.61 83.21,55.22 84.39,55.22 84.88,54.74 84.88,53.4 85.6,52.68 102.69,52.68 103.29,52.08 128.19,52.08 130.6,49.67 134.3,49.67 135.62,48.35 135.62,46.94 v2(135.29,46.61)
  L7_SIG w0.091: P502.13 81.88,51.55 82.01,51.67 82.01,52.56 81.88,52.69 80.14,52.69 79.75,53.07 79.75,54.64 78.66,55.74 73.48,55.74 70.11,52.37 45.86,52.37 44.38,50.9 40.06,50.9 39.92,50.76 39.92,50.59 39.71,50.39 35.52,50.39 35.12,50.79 34.86,50.79 34.85,50.78 v6(34.84,50.78)
  BOTTOM w0.203: P801.G21 v2(135.29,46.61)
GPIO_12: length 117.8
  TOP w0.254: U101.H11 v6(34.84,49.98)
  L5_SIG w0.091: P502.14 81.16,53.16 81.38,52.94 81.73,52.94 82.34,53.55 82.34,54.72 83.1,55.48 84.5,55.48 85.13,54.84 85.13,53.51 85.71,52.94 102.8,52.94 103.4,52.34 128.29,52.34 130.7,49.92 134.41,49.92 135.88,48.46 135.88,47.29 v2(136.56,46.61)
  L7_SIG w0.091: v6(34.84,49.98) 34.84,50.31 34.51,50.63 34.51,50.91 34.75,51.15 44.28,51.15 45.75,52.62 70.01,52.62 73.37,55.99 78.77,55.99 80.01,54.75 80.01,53.18 80.24,52.94 81.07,52.94 81.16,53.03 P502.14
  BOTTOM w0.203: P801.G22 v2(136.56,46.61)
GPIO_13: length 121.9
  TOP w0.254: U101.J11 v6(35.64,49.98)
  L7_SIG w0.091: P502.15 78.62,52.6 78.53,52.69 77.85,52.69 77.54,52.38 77.54,51.03 76.12,49.62 75.42,49.62 73.48,47.67 52.21,47.67 51.6,48.28 49.44,48.28 49.09,47.93 42.55,47.93 42.02,47.4 39.99,47.4 39.79,47.2 39.48,47.2 39.26,47.42 38.77,47.42 38.14,48.05 37.9,48.05 37.71,48.24 37.71,48.48 37.34,48.85 37.1,48.85 36.91,49.04 36.91,49.31 36.83,49.39 36.7,49.39 36.54,49.54 36.07,49.54 v6(35.64,49.98)
  L8_SIG w0.091: v2(136.56,35.18) 136.15,34.77 136.15,34.2 135.45,33.49 130.23,33.49 128.36,35.36 125.52,35.36 113.21,47.67 102.75,47.67 97.78,52.65 95.87,52.65 94.96,53.56 94.96,54.59 94.14,55.42 85.82,55.42 85.13,54.74 85.13,53.41 84.42,52.7 79.29,52.7 78.62,52.03 P502.15
  BOTTOM w0.203: v2(136.56,35.18) P801.G31
GPIO_14: length 121.8
  TOP w0.254: U101.K11 v6(36.44,49.98)
  L7_SIG w0.091: v6(36.44,49.98) 36.47,49.98 36.8,49.64 36.94,49.64 37.08,49.5 37.37,49.5 37.56,49.31 37.56,48.99 37.85,48.7 38.17,48.7 38.36,48.51 38.36,48.19 38.88,47.67 39.2,47.67 39.48,47.95 39.79,47.95 40.1,47.65 41.92,47.65 42.45,48.18 48.98,48.18 49.34,48.54 51.7,48.54 52.31,47.93 73.37,47.93 75.32,49.87 76.02,49.87 77.29,51.14 77.29,52.49 77.74,52.94 78.97,52.94 79.1,53.07 79.1,53.96 78.97,54.09 P502.16
  L8_SIG w0.091: v2(135.29,35.18) 135.59,35.18 135.9,34.87 135.9,34.3 135.34,33.74 130.34,33.74 128.46,35.62 125.62,35.62 113.31,47.93 102.86,47.93 97.88,52.9 95.98,52.9 95.22,53.66 95.22,54.7 94.24,55.67 85.71,55.67 84.88,54.84 84.88,53.52 84.32,52.95 79.29,52.95 78.62,53.62 P502.16
  BOTTOM w0.203: v2(135.29,35.18) P801.G30
GPIO_15: length 147
  TOP w0.254: U101.L11 v6(37.24,49.98)
  L5_SIG w0.091: v2(135.29,42.8) 135.29,42.57 135.86,42 138.6,42 139.06,42.46 139.06,50.35 136.91,52.5 131.33,52.5 130.06,53.77 124.22,53.77 123.96,54.02 103.24,54.02 102.98,54.28 99.3,54.28 97.4,56.18 85.86,56.18 85.67,55.99 81.01,55.99 79.86,54.84 79.86,53.64 79.1,52.88 78.17,52.88 76.84,51.55 P502.17
  L10_SIG w0.091: P502.17 75.07,51.55 74.88,51.35 74.88,50.47 75.08,50.26 76.65,50.26 77.13,50.74 77.74,50.74 78.17,50.31 79.06,50.31 79.52,50.77 80.08,50.77 80.46,50.39 83.2,50.39 83.33,50.26 83.33,49.75 83.2,49.62 79.89,49.62 79.85,49.58 79.43,49.58 79.39,49.62 73.55,49.62 70.21,52.96 46.27,52.96 44.56,54.66 37.86,54.66 36.79,53.59 36.79,50.07 36.88,49.98 v6(37.24,49.98)
  BOTTOM w0.203: P801.G24 v2(135.29,42.8)
GPIO_16: length 112.5
  TOP w0.254: U101.M11 v6(38.04,49.98)
  L5_SIG w0.091: P502.18 74.72,52.72 74.72,52.59 74.9,52.41 75.03,52.41 75.52,52.9 76.36,52.9 77.27,53.81 77.27,55.46 79.37,57.56 80.35,57.56 80.9,57.02 103.04,57.02 104.76,55.29 114.58,55.29 116.49,57.2 122.03,57.2 122.54,56.69 132.34,56.69 132.72,56.32 135.51,56.32 136.06,55.77 136.06,54.32 136.15,54.23 v2(136.56,54.23)
  L7_SIG w0.091: v6(38.04,49.98) 38.35,49.98 38.82,49.5 40.83,49.5 41.03,49.7 47.78,49.7 48.8,50.72 70.29,50.72 72.56,52.99 74.98,52.99 P502.18
  BOTTOM w0.394: P801.G16 v2(136.56,54.23)
GPIO_17: length 112.5
  TOP w0.254: U101.M10 v6(38.04,49.18)
  L5_SIG w0.091: v2(135.29,54.23) 135.8,54.74 135.8,55.67 135.4,56.06 132.61,56.06 132.24,56.43 122.44,56.43 121.93,56.94 116.59,56.94 114.69,55.04 104.66,55.04 102.93,56.76 80.79,56.76 80.25,57.31 79.48,57.31 77.52,55.36 77.52,53.71 76.46,52.65 75.63,52.65 74.53,51.55 P502.19
  L7_SIG w0.091: v6(38.04,49.18) 38.38,49.18 38.77,48.79 38.91,48.79 39.16,49.04 39.22,49.04 39.47,48.79 39.75,48.79 39.94,48.98 39.94,49.16 40.02,49.25 40.93,49.25 41.14,49.45 47.89,49.45 48.9,50.47 70.4,50.47 72.66,52.73 74.83,52.73 74.99,52.57 74.99,51.64 74.89,51.55 P502.19
  BOTTOM w0.394: P801.G15 v2(135.29,54.23)
GPIO_18: length 125.2
  TOP w0.254: U101.J3 v6(35.64,43.58)
  TOP w0.305: R518.1 R521.1 73.66,56.13 73.66,54.2 P502.20
  L5_SIG w0.114: P502.20 73.54,54.15 79.26,59.87 87.16,59.87 87.17,59.86 100.59,59.86 105.22,64.49 124.97,64.49 127.12,62.34 129.36,62.34 130.44,61.26 137.15,61.26 v2(140.37,58.04)
  L8_SIG w0.097: 39.41,46.38 39.76,46.38
  L8_SIG w0.114: P502.20 73.54,53.87 67.72,48.05 60.33,48.05 59.6,47.32 54.29,47.32 54.1,47.14 51.39,47.14 51.38,47.13 50.39,47.13 50.3,47.22 48.95,47.22 47.36,45.64 40.52,45.64 39.78,46.38 39.76,46.38 ; v6(35.64,43.58) 35.47,43.58 35.01,44.04 35.01,45.68 35.19,45.85 35.19,46.02 36.28,47.11 36.58,47.11 36.85,46.84 36.85,46.62 37.08,46.38 39.41,46.38
  BOTTOM w0.203: v2(140.37,58.04) 139.92,58.49 139.88,58.49 139.74,58.63 P801.D12
INPUT_VOLTAGE: length 42.1
  TOP w0.203: CR701.C 121.36,18.14 DS701.A
  TOP w0.305: R602.2 v1(55.9,19.99)
  L7_SIG w0.114: v1(55.9,19.99) 56.41,19.48 60.21,19.48 62.37,17.32 80.18,17.32 v1(84.09,21.22)
  BOTTOM w0.254: v1(93.15,25.51) 92.8,25.87 v1(92.49,25.87) ; U701.22 86.25,21.86 v1(85.59,21.2) ; 83.53,29.12 84.03,28.62 U701.36 ; U701.38 85.75,29.8 85.26,30.29 ; v1(92.49,25.87) 92.24,26.12 U701.6 ; v1(92.49,25.87) 92.24,25.62 U701.7
  BOTTOM w0.394: R709.1 v1(92.94,31.09)
  vias: v1(83.38,30.98) v1(83.71,29.43) v1(84.24,30.98) v1(84.57,29.43) v1(84.82,21.2) v1(98.77,26.02) v1(98.77,25.13) v1(98.77,24.27) v7(117.74,18.72) v7(117.74,17) v7(119.26,18.72) v7(119.26,17) v7(123.71,18.72) v7(123.71,17) v7(125.23,18.72) v7(125.23,17)
JTAG_TDI: length 1.6
  TOP w0.305: v2(140.37,35.18) 140.04,34.85 R815.2
  BOTTOM w0.394: v2(140.37,35.18) P801.D30
JTAG_TDO: length 1.6
  TOP w0.305: R815.1 140.07,34.21 v2(140.37,33.91)
  BOTTOM w0.394: v2(140.37,33.91) P801.D31
LDO_VCO_2P5: length 3.4
  BOTTOM w0.254: C413.1 86.31,65.96 86.26,66.01 C412.1 86.26,66.94 86.55,67.23 86.55,67.74 86.54,67.75 86.54,68.07 U401.15
LF_EXT_CAP: length 3.1
  BOTTOM w0.203: 90.4,66.59 C410.2
  BOTTOM w0.254: U401.7 90.54,67.88 90.54,66.69 C410.2 ; R415.2 89.95,66.58 89.96,66.59 90.4,66.59
LF_PLL2: length 2.2
  BOTTOM w0.254: U401.14 87.04,67.52 87.25,67.31 C412.2
ORX1+: length 7.6
  BOTTOM w0.203: C232.2 L232.1 24,53.89 arc(24.06,53.79) 24.13,53.7 arc(25.74,51.94) 27.71,50.6 arc(28.06,50.47) 28.43,50.42 arc(28.64,50.41) v5(28.84,50.38) ; 23.26,54.75 R231.2 23.26,54.75 ; 23.26,54.75 arc(23.39,54.7) 23.49,54.6 ; 23.26,54.75 arc(23.39,54.7) 23.49,54.6
ORX1-: length 7.5
  BOTTOM w0.203: C232.1 L232.2 24.29,54.09 arc(24.35,54) 24.42,53.9 arc(25.98,52.21) 27.87,50.92 arc(28.14,50.81) 28.43,50.78 arc(28.52,50.78) 28.61,50.8 arc(28.71,50.85) 28.8,50.91 arc(28.86,51.04) v5(28.84,51.18) ; 23.72,55.07 C230.2 23.72,55.07 arc(23.72,54.93) 23.78,54.8 arc(23.72,54.93) 23.72,55.07
ORX2+: length 7
  BOTTOM w0.203: C239.2 23.72,38.48 arc(23.72,38.62) 23.78,38.75 ; C240.2 L240.1 24.29,39.46 arc(25.89,41.26) 27.87,42.64 arc(28.14,42.74) 28.43,42.78 arc(28.52,42.77) 28.61,42.75 arc(28.71,42.71) 28.8,42.64 arc(28.86,42.51) v5(28.84,42.38)
ORX2-: length 7.1
  BOTTOM w0.203: C240.1 L240.2 24,39.66 arc(25.65,41.53) 27.71,42.95 arc(28.06,43.09) 28.43,43.13 arc(28.64,43.14) v5(28.84,43.18) ; R238.2 23.26,38.81 arc(23.39,38.86) 23.49,38.95
OUT: length 4.9
  BOTTOM w0.203: Y401.4 Y403.3 Y402.4 111.2,71.42 110.48,72.15 R410.1
RESETB: length 117.3
  TOP w0.254: U101.J4 v6(35.64,44.38)
  TOP w0.394: TP804.1 128.26,61.2 R802.1
  L5_SIG w0.114: TP804.1 127.59,61.01 118.63,61.01 117.35,59.73 117.1,59.73 113.55,56.18 106.31,56.18 103.8,58.69 79.1,58.69 74.81,54.4 74.81,53.64 74.09,52.92 v5(40.9,52.92) 40.83,52.92 39.89,51.98 38.65,51.98 38.44,51.78 38.44,48.22 39.23,47.44 39.23,46.62 39.22,46.61 39.22,45.04 39,44.81 38.74,44.81 38.44,44.51 38.44,44.23 38.14,43.93 36.08,43.93 v6(35.64,44.38)
  BOTTOM w0.305: R502.2 40.16,51.31 40.9,52.05 v5(40.9,52.92)
RX1+: length 7.9
  TOP w0.203: U101.A9 28.7,48.11 arc(28.58,48.19) 28.44,48.22 arc(27.95,48.3) 27.51,48.53 23.76,51.2 arc(23.52,51.32) L207.1 ; C207.1 L207.1 ; L207.1 arc(23.16,51.34) 23.07,51.36 arc(22.61,51.29) 22.2,51.08
RX1-: length 7.9
  TOP w0.203: U101.A10 28.74,48.68 arc(28.63,48.6) 28.5,48.58 28.44,48.58 arc(28.06,48.64) 27.73,48.82 27.72,48.82 23.96,51.49 23.75,51.61 arc(23.51,51.71) L207.2 ; 23.06,51.72 23.07,51.71 23.06,51.71 arc(23.16,51.73) L207.2 ; C207.2 L207.2 ; 23.07,51.71 arc(22.61,51.78) R206.2
RX1_ENABLE: length 64.2
  TOP w0.254: U101.M5 v6(38.04,44.38)
  TOP w0.305: P501.7 76.27,65.01 R508.1
  L5_SIG w0.114: v6(38.04,44.38) 37.67,44.74 37.2,44.74 36.77,45.16 36.77,45.32 36.06,46.03 36.06,46.87 35.69,47.24 35.49,47.24 35.3,47.43 35.3,52.19 36.08,52.96 36.08,53.77 37.35,55.04 38.36,55.04 40.89,57.56 69.34,57.56 71.89,60.12 71.89,64.74 73.3,66.15 74.3,66.15 75.51,64.94 P501.7
  BOTTOM w0.203: 76.21,66.42 P501.7
RX2+: length 7.9
  TOP w0.203: 23.06,41.84 23.07,41.84 23.06,41.84 ; 23.06,41.84 arc(23.16,41.82) 23.25,41.81 ; U101.A5 28.74,44.87 arc(28.63,44.95) 28.5,44.97 28.44,44.97 arc(28.06,44.91) 27.73,44.74 27.72,44.73 23.96,42.06 23.75,41.94 arc(23.51,41.84) 23.25,41.81 ; C216.1 23.25,41.81 ; 23.07,41.84 arc(22.61,41.77) 22.2,41.56
RX2-: length 7.9
  TOP w0.203: U101.A6 28.7,45.44 arc(28.58,45.36) 28.44,45.33 arc(27.95,45.25) 27.51,45.02 23.76,42.35 arc(23.52,42.24) 23.25,42.22 ; 23.25,42.33 L216.2 23.25,42.22 ; 23.25,42.22 arc(23.16,42.21) 23.07,42.19 arc(22.61,42.26) 22.2,42.47
RX2_ENABLE: length 53.4
  TOP w0.254: U101.M7 v6(38.04,46.78)
  TOP w0.305: R509.1 76.27,62.34 P501.8
  L5_SIG w0.114: v6(38.04,46.78) 38.37,47.11 38.37,47.72 38.05,48.04 37.9,48.04 37.63,48.31 37.63,48.54 37.63,48.54 37.63,51.88 38.49,52.74 40.09,52.74 41.68,54.33 68.71,54.33 76.21,61.83 P501.8
  BOTTOM w0.203: 76.21,60.93 P501.8
RX_EXTLO+: length 6.7
  TOP w0.203: U101.B8 v6(29.24,47.58)
  L10_SIG w0.091: v6(29.24,47.58) 29.24,46.9 arc(29.19,46.77) 29.06,46.72 28.68,46.72 arc(28.62,46.73) 28.57,46.76 arc(28.42,46.87) 28.23,46.9 24.96,46.9 arc(24.74,46.95) v5(24.56,47.07)
  BOTTOM w0.203: C332.2 v5(24.56,47.07)
RX_EXTLO-: length 6.6
  TOP w0.203: U101.B7 v6(29.24,45.98)
  L10_SIG w0.091: v6(29.24,45.98) 29.24,46.29 arc(29.19,46.41) 29.06,46.47 28.68,46.47 arc(28.52,46.5) 28.39,46.58 arc(28.32,46.63) 28.23,46.65 24.99,46.65 arc(24.68,46.52) 24.56,46.22 v5(24.56,46.15)
  BOTTOM w0.203: C333.2 v5(24.56,46.15)
SERDIN0+: length 3
  BOTTOM w0.203: P801.A26 143.55,40.64 arc(143.61,40.5) 143.75,40.44 145.7,40.44 arc(145.87,40.47) 146.02,40.57 C508.1
SERDIN0-: length 3
  BOTTOM w0.203: C507.1 146.02,39.95 arc(145.87,40.05) 145.7,40.08 143.75,40.08 arc(143.61,40.02) 143.55,39.88 P801.A27
SERDIN1+: length 1.4
  TOP w0.203: v2(141.64,70.74) C510.1
  BOTTOM w0.203: P801.C2 v2(141.64,70.74)
SERDIN1-: length 2.2
  TOP w0.203: v2(141.64,69.47) C509.1 v2(141.64,69.47)
  BOTTOM w0.203: 141.19,69.92 141.19,69.94 141.03,70.1 P801.C3 141.19,69.92 ; 141.19,69.92 v2(141.64,69.47)
SERDIN2+: length 3
  BOTTOM w0.203: C512.1 146.02,35.49 arc(145.87,35.39) 145.7,35.36 143.75,35.36 arc(143.61,35.42) 143.55,35.56 P801.A30
SERDIN2-: length 3
  BOTTOM w0.203: P801.A31 143.55,34.8 arc(143.61,34.94) 143.75,35 145.7,35 arc(145.87,34.97) 146.02,34.87 C511.1
SERDIN3+: length 3
  BOTTOM w0.203: P801.A22 143.55,45.72 arc(143.61,45.58) 143.75,45.52 145.7,45.52 arc(145.87,45.55) 146.02,45.65 C514.1
SERDIN3-: length 3
  BOTTOM w0.203: C513.1 146.02,45.03 arc(145.87,45.13) 145.7,45.16 143.75,45.16 arc(143.61,45.1) 143.55,44.96 P801.A23
SERDOUT0+: length 3
  BOTTOM w0.203: C516.1 146.02,71.05 arc(145.87,70.95) 145.7,70.92 143.75,70.92 arc(143.61,70.98) 143.55,71.12 P801.A2
SERDOUT0-: length 3
  BOTTOM w0.203: C515.1 146.02,70.43 arc(145.87,70.53) 145.7,70.56 143.75,70.56 arc(143.61,70.5) 143.55,70.36 P801.A3
SERDOUT1+: length 3
  BOTTOM w0.203: P801.A6 143.55,66.04 arc(143.61,65.9) 143.75,65.84 145.7,65.84 arc(145.87,65.87) 146.02,65.97 C518.1
SERDOUT1-: length 3
  BOTTOM w0.203: P801.A7 143.55,65.28 arc(143.61,65.42) 143.75,65.48 145.7,65.48 arc(145.87,65.45) 146.02,65.35 C517.1
SERDOUT2+: length 1.4
  TOP w0.203: C520.1 141.67,65.63 v2(141.67,65.65)
  BOTTOM w0.203: P801.C6 141.66,65.65 v2(141.67,65.65)
SERDOUT2-: length 1.4
  TOP w0.203: v2(141.64,64.39) C519.1
  BOTTOM w0.203: v2(141.64,64.39) P801.C7
SERDOUT3+: length 3
  BOTTOM w0.203: C522.1 146.02,60.89 arc(145.87,60.79) 145.7,60.76 143.75,60.76 arc(143.61,60.82) 143.55,60.96 P801.A10
SERDOUT3-: length 3
  BOTTOM w0.203: C521.1 146.02,60.27 arc(145.87,60.37) 145.7,60.4 143.75,60.4 arc(143.61,60.34) 143.55,60.2 P801.A11
SNRXA+: length 16.3
  TOP w0.254: U101.E4 v6(31.64,43.58)
  L10_SIG w0.091: v6(31.64,43.58) 31.74,43.47 31.82,43.4 arc(31.96,43.18) 32.01,42.92 32.01,41.99 arc(31.9,41.72) 31.62,41.6 arc(31.54,41.6) 31.47,41.58 arc(31.44,41.57) 31.42,41.56 arc(31.32,41.51) 31.24,41.44 arc(31.02,41.3) 30.76,41.24 30.6,41.24 arc(30.31,41.12) 30.18,40.83 30.18,36.18 arc(30.08,35.64) 29.77,35.17 29.71,35.12 arc(29.36,34.67) 29.11,34.17 arc(28.65,32.82) 28.25,31.47 arc(28.22,31.25) v5(28.25,31.04)
  BOTTOM w0.203: C224.1 L224.1 28.09,30.79 arc(28.16,30.92) v5(28.25,31.04) ; C222.2 27.72,29.55 arc(27.68,29.68) 27.71,29.82
