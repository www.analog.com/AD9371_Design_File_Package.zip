# Allegro board ADRV9371-N_PCBZ_Layout_RevB.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
CNSAMTECTSW-108-08-G-D-ST
  rect 1.651x1.651 hole 1.143: 1(0,0)
  round 1.651 hole 1.143: 2(0,2.54) 3(2.54,0) 4(2.54,2.54) 5(5.08,0) 6(5.08,2.54) 7(7.62,0) 8(7.62,2.54) 9(10.16,0) 10(10.16,2.54) 11(12.7,0) 12(12.7,2.54) 13(15.24,0) 14(15.24,2.54) 15(17.78,0) 16(17.78,2.54)
CNWIELAND3225
  rect 2.159x2.159 hole 1.651: 1(0,0)
  round 2.159 hole 1.651: 2(5,0)
DO214AA3
  rect 1.778x2.159 smd: A(2.032,0) C(-2.032,0)
ETC1
  rect 0.762x1.397 smd: 1(-1.27,1.714) 2(0,1.714) 3(1.27,1.714) 4(1.27,-1.714) 5(-1.27,-1.714)
F1206
  rect 1.143x2.032 smd: 1(-1.333,0) 2(1.333,0)
L0201
  rect 0.178x0.33 smd: 1(-0.203,0) 2(0.203,0)
L0402
  rect 0.889x0.813 smd: 1(-0.635,0) 2(0.635,0)
L0603
  rect 0.889x0.813 smd: 1(-0.737,0)
  rect 0.594x0.813 smd: 2(0.737,0)
L0805
  rect 1.143x1.27 smd: 1(-0.953,0) 2(0.953,0)
LCC4H210
  rect 1.27x2.286 smd: 1(-2.54,-3.556) 2(2.54,-3.556) 3(2.54,3.556) 4(-2.54,3.556)
LED0603
  rect 0.965x0.762 smd: A(0.8,0) C(-0.8,0)
LED0603-2
  rect 0.787x0.787 smd: A(0.787,0) C(-0.787,0)
LSMSQ157H83
  rect 1.473x3.683 smd: 1(-1.232,0) 2(1.232,0)
LSMSQ157H122
  rect 0.965x3.708 smd: 1(-1.181,0) 2(1.181,0)
MSOP8_PAD2_16X1_73
  rect 0.33x1.575 smd: 1(-0.975,-2.171) 2(-0.325,-2.171) 3(0.325,-2.171) 4(0.975,-2.171) 5(0.975,2.171) 6(0.325,2.171) 7(-0.325,2.171) 8(-0.975,2.171)
  rect 2.159x1.727 smd: PAD(0,0)
POWERPAKSC70-6
  rect 0.305x0.33 smd: 1(-0.65,-0.91) 2(0,-0.91) 3(0.65,-0.91) 4(0.65,0.91) 5(0,0.91) 6(-0.65,0.91)
  rect 0.61x0.94 smd: PAD1(-0.465,0) PAD2(0.465,0)
QFN20_4X4_PAD2_6X2_6
  oval 0.305x1.041 smd: 1(-1,-2.019) 2(-0.5,-2.019) 3(0,-2.019) 4(0.5,-2.019) 5(1,-2.019) 11(1,2.019) 12(0.5,2.019) 13(0,2.019) 14(-0.5,2.019) 15(-1,2.019)
  oval 1.041x0.305 smd: 6(2.019,-1) 7(2.019,-0.5) 8(2.019,0) 9(2.019,0.5) 10(2.019,1) 16(-2.019,1) 17(-2.019,0.5) 18(-2.019,0) 19(-2.019,-0.5) 20(-2.019,-1)
  rect 2.591x2.591 smd: PAD(0,0)
QFN48_7X7_PAD5_6X5_6
  oval 0.305x0.94 smd: 1(-2.75,-3.5) 2(-2.25,-3.5) 3(-1.75,-3.5) 4(-1.25,-3.5) 5(-0.75,-3.5) 6(-0.25,-3.5) 7(0.25,-3.5) 8(0.75,-3.5) 9(1.25,-3.5) 10(1.75,-3.5) 11(2.25,-3.5) 12(2.75,-3.5) 25(2.75,3.5) 26(2.25,3.5) 27(1.75,3.5) 28(1.25,3.5) 29(0.75,3.5) 30(0.25,3.5) 31(-0.25,3.5) 32(-0.75,3.5) 33(-1.25,3.5) 34(-1.75,3.5) 35(-2.25,3.5) 36(-2.75,3.5)
  oval 0.94x0.305 smd: 13(3.5,-2.75) 14(3.5,-2.25) 15(3.5,-1.75) 16(3.5,-1.25) 17(3.5,-0.75) 18(3.5,-0.25) 19(3.5,0.25) 20(3.5,0.75) 21(3.5,1.25) 22(3.5,1.75) 23(3.5,2.25) 24(3.5,2.75) 37(-3.5,2.75) 38(-3.5,2.25) 39(-3.5,1.75) 40(-3.5,1.25) 41(-3.5,0.75) 42(-3.5,0.25) 43(-3.5,-0.25) 44(-3.5,-0.75) 45(-3.5,-1.25) 46(-3.5,-1.75) 47(-3.5,-2.25) 48(-3.5,-2.75)
  rect 5.588x5.588 smd: PAD(0,0)
QFN72_10X10_PAD5_3X5_3
  oval 0.305x0.838 smd: 1(-4.25,-4.95) 2(-3.75,-4.95) 3(-3.25,-4.95) 4(-2.75,-4.95) 5(-2.25,-4.95) 6(-1.75,-4.95) 7(-1.25,-4.95) 8(-0.75,-4.95) 9(-0.25,-4.95) 10(0.25,-4.95) 11(0.75,-4.95) 12(1.25,-4.95) 13(1.75,-4.95) 14(2.25,-4.95) 15(2.75,-4.95) 16(3.25,-4.95) 17(3.75,-4.95) 18(4.25,-4.95) 37(4.25,4.95) 38(3.75,4.95) 39(3.25,4.95) 40(2.75,4.95) 41(2.25,4.95) 42(1.75,4.95) 43(1.25,4.95) 44(0.75,4.95) 45(0.25,4.95) 46(-0.25,4.95) 47(-0.75,4.95) 48(-1.25,4.95) 49(-1.75,4.95) 50(-2.25,4.95) 51(-2.75,4.95) 52(-3.25,4.95) 53(-3.75,4.95) 54(-4.25,4.95)
  oval 0.838x0.305 smd: 19(4.95,-4.25) 20(4.95,-3.75) 21(4.95,-3.25) 22(4.95,-2.75) 23(4.95,-2.25) 24(4.95,-1.75) 25(4.95,-1.25) 26(4.95,-0.75) 27(4.95,-0.25) 28(4.95,0.25) 29(4.95,0.75) 30(4.95,1.25) 31(4.95,1.75) 32(4.95,2.25) 33(4.95,2.75) 34(4.95,3.25) 35(4.95,3.75) 36(4.95,4.25) 55(-4.95,4.25) 56(-4.95,3.75) 57(-4.95,3.25) 58(-4.95,2.75) 59(-4.95,2.25) 60(-4.95,1.75) 61(-4.95,1.25) 62(-4.95,0.75) 63(-4.95,0.25) 64(-4.95,-0.25) 65(-4.95,-0.75) 66(-4.95,-1.25) 67(-4.95,-1.75) 68(-4.95,-2.25) 69(-4.95,-2.75) 70(-4.95,-3.25) 71(-4.95,-3.75) 72(-4.95,-4.25)
  rect 5.994x5.994 smd: PAD(0,0)
R0201
  rect 0.305x0.406 smd: 1(-0.318,0) 2(0.318,0)
R0402
  rect 0.889x0.813 smd: 1(-0.635,0) 2(0.635,0)
R0402#2
  rect 0.61x0.61 smd: 1(-0.495,0) 2(0.495,0)
R0603
  rect 1.092x1.194 smd: 1(-0.851,0) 2(0.851,0)
SC70
  rect 0.406x0.508 smd: 1(-0.65,-0.95) 2(0,-0.95) 3(0.65,-0.95) 4(0.65,0.95) 5(0,0.95) 6(-0.65,0.95)
SC70-6
  rect 0.406x0.508 smd: 1(-0.65,-0.95) 2(0,-0.95) 3(0.65,-0.95) 4(0.65,0.95) 5(0,0.95) 6(-0.65,0.95)
T0603-6P
  rect 0.254x0.559 smd: 1(-0.504,-0.43) 2(0,-0.43) 3(0.504,-0.43) 4(0.504,0.43) 5(0,0.43) 6(-0.504,0.43)
T0805_A
  rect 0.305x0.787 smd: 1(-0.65,-0.644) 2(0,-0.644) 3(0.65,-0.644) 4(0.65,0.644) 5(0,0.644) 6(-0.65,0.644)
TSSOP8
  rect 0.33x1.651 smd: 1(-0.975,-2.92) 2(-0.325,-2.92) 3(0.325,-2.92) 4(0.975,-2.92) 5(0.975,2.92) 6(0.325,2.92) 7(-0.325,2.92) 8(-0.975,2.92)
TSSOP14
  rect 0.432x1.778 smd: 1(-1.95,-2.92) 2(-1.3,-2.92) 3(-0.65,-2.92) 4(0,-2.92) 5(0.65,-2.92) 6(1.3,-2.92) 7(1.95,-2.92) 8(1.95,2.92) 9(1.3,2.92) 10(0.65,2.92) 11(0,2.92) 12(-0.65,2.92) 13(-1.3,2.92) 14(-1.95,2.92)
unnamed#2
  round 3.81 hole 2.54 unplated: (0,0)
US8
  rect 0.305x0.711 smd: 1(-0.75,-1.343) 2(-0.25,-1.343) 3(0.25,-1.343) 4(0.75,-1.343) 5(0.75,1.343) 6(0.25,1.343) 7(-0.25,1.343) 8(-0.75,1.343)
XFMR2450BL15B050
  rect 0.356x0.991 smd: 1(-0.656,-0.895) 2(0,-0.895) 3(0.656,-0.895) 4(0.656,0.895) 5(0,0.895) 6(-0.656,0.895)
YSML276W197H71
  rect 1.803x2.007 smd: 1(-2.54,-2) 2(0,-2) 3(2.54,-2) 4(2.54,2) 5(0,2) 6(-2.54,2)
YSML555W358H240
  rect 1.27x2.54 smd: 1(-2.54,-4.064) 2(0,-4.064) 3(2.54,-4.064) 4(2.54,4.064) 5(0,4.064) 6(-2.54,4.064)

## Nets
AGND: C200.2(N2) C202.2(N2) C203.2(N2) C208.2(N2) C211.2(N2) C212.2(N2) C217.2(N2) C219.2(N2) C220.2(N2) C225.2(N2) C227.2(N2) C228.2(N2) C233.2(N2) C235.2(N2) C236.1(N1) C307.2(N2) C308.2(N2) C315.2(N2) C316.2(N2) C320.2(N2) C321.2(N2) C322.2(N2) C323.2(N2) C324.2(N2) C325.2(N2) C326.2(N2) C327.2(N2) C328.2(N2) C329.2(N2) C330.2(N2) C331.2(N2) C334.2(N2) C335.2(N2) C404.2(N2) C405.1(N1) C406.1(N1) C410.1(N1) C411.1(N1) C413.2(N2) C414.1(N1) C415.1(N1) C416.1(N1) C417.1(N1) C418.1(N1) C419.1(N1) C420.2(N2) C421.1(N1) C422.1(N1) C423.1(N1) C424.1(N1) C425.1(N1) C426.1(N1) C427.1(N1) C428.1(N1) C429.1(N1) C430.1(N1) C431.1(N1) C432.1(N1) C433.1(N1) C434.1(N1) C435.1(N1) C436.1(N1) C437.1(N1) C438.1(N1) C439.1(N1) C503.2(N2) C504.2(N2) C505.2(N2) C506.2(N2) C523.2(N2) C524.2(N2) C525.2(N2) C526.2(N2) C527.2(N2) C528.2(N2) C529.2(N2) C530.2(N2) C531.2(N2) C532.2(N2) C601.2(N2) C602.2(N2) C603.2(N2) C604.2(N2) C605.2(N2) C606.2(N2) C608.2(N2) C609.2(N2) C610.2(N2) C611.2(N2) C612.2(N2) C613.2(N2) C614.2(N2) C615.2(N2) C616.2(N2) C617.2(N2) C618.2(N2) C619.2(N2) C620.2(N2) C621.2(N2) C622.2(N2) C623.2(N2) C624.2(N2) C625.2(N2) C626.2(N2) C627.2(N2) C628.2(N2) C629.2(N2) C630.2(N2) C631.2(N2) C632.2(N2) C633.2(N2) C634.2(N2) C635.2(N2) C636.2(N2) C637.2(N2) C638.2(N2) C639.2(N2) C640.2(N2) C641.2(N2) C642.2(N2) C643.2(N2) C644.2(N2) C645.2(N2) C646.2(N2) C647.2(N2) C648.2(N2) C649.2(N2) C650.2(N2) C651.2(N2) C652.2(N2) C653.2(N2) C654.2(N2) C701.2(N2) C702.1(N1) C703.1(N1) C704.1(N1) C705.2(N2) C706.1(N1) C707.2(N2) C708.1(N1) C709.2(N2) C710.1(N1) C711.1(N1) C712.1(N1) C721.2(N2) C722.2(N2) C723.2(N2) C725.2(N2) C726.2(N2) C728.2(N2) C730.2(N2) C732.2(N2) C733.1(N1) C734.1(N1) C735.1(N1) C736.2(N2) C737.1(N1) C738.1(N1) C739.2(N2) C803.1(N1) C804.2(N2) D401.C(N) D402.C(N) DS702.C(N) J200.2(SH1) J200.3(SH2) J200.4(SH3) J200.5(SH4) J201.2(SH1) J201.3(SH2) J201.4(SH3) J201.5(SH4) J202.2(SH1) J202.3(SH2) J202.4(SH3) J202.5(SH4) J203.2(SH1) J203.3(SH2) J203.4(SH3) J203.5(SH4) J204.2(SH1) J204.3(SH2) J204.4(SH3) J204.5(SH4) J305.2(SH1) J305.3(SH2) J305.4(SH3) J305.5(SH4) J306.2(SH1) J306.3(SH2) J306.4(SH3) J306.5(SH4) J307.2(SH1) J307.3(SH2) J307.4(SH3) J307.5(SH4) J308.2(SH1) J308.3(SH2) J308.4(SH3) J308.5(SH4) J401.2(SH1) J401.3(SH2) J401.4(SH3) J401.5(SH4) L200.1(N1) L202.1(N1) L208.1(N1) L211.1(N1) L217.1(N1) L219.1(N1) L225.1(N1) L227.1(N1) L233.1(N1) L235.1(N1) L323.1(N1) L324.1(N1) L328.1(N1) L329.1(N1) P501.1(N1) P501.2(N2) P502.1(N1) P503.1(N1) P503.3(N2) P503.14(N7) P503.16(N8) P504.3(N2) P504.5(N3) P504.9(N5) P504.15(N8) P504.19(N10) P701.2(N2) P703.2(N2) P704.2(N2) P705.2(N2) P706.2(N2) P707.2(N2) P801.A1(N1) P801.A4(N4) P801.A5(N5) P801.A8(N8) P801.A9(N9) P801.A12(N12) P801.A13(N13) P801.A16(N16) P801.A17(N17) P801.A20(N20) P801.A21(N21) P801.A24(N24) P801.A25(N25) P801.A28(N28) P801.A29(N29) P801.A32(N32) P801.A33(N33) P801.A36(N36) P801.A37(N37) P801.A40(N40) P801.B2(N2) P801.B3(N3) P801.B6(N6) P801.B7(N7) P801.B10(N10) P801.B11(N11) P801.B14(N14) P801.B15(N15) P801.B18(N18) P801.B19(N19) P801.B22(N22) P801.B23(N23) P801.B26(N26) P801.B27(N27) P801.B30(N30) P801.B31(N31) P801.B34(N34) P801.B35(N35) P801.B38(N38) P801.B39(N39) P801.C1(N1) P801.C4(N4) P801.C5(N5) P801.C8(N8) P801.C9(N9) P801.C12(N12) P801.C13(N13) P801.C16(N16) P801.C17(N17) P801.C20(N20) P801.C21(N21) P801.C24(N24) P801.C25(N25) P801.C28(N28) P801.C29(N29) P801.C32(N32) P801.C33(N33) P801.C36(N36) P801.C38(N38) P801.C40(N40) P801.D2(N2) P801.D3(N3) P801.D6(N6) P801.D7(N7) P801.D10(N10) P801.D13(N13) P801.D16(N16) P801.D19(N19) P801.D22(N22) P801.D25(N25) P801.D28(N28) P801.D37(N37) P801.D39(N39) P801.E1(N1) P801.E4(N4) P801.E5(N5) P801.E8(N8) P801.E11(N11) P801.E14(N14) P801.E17(N17) P801.E20(N20) P801.E23(N23) P801.E26(N26) P801.E29(N29) P801.E32(N32) P801.E35(N35) P801.E38(N38) P801.E40(N40) P801.F2(N2) P801.F3(N3) P801.F6(N6) P801.F9(N9) P801.F12(N12) P801.F15(N15) P801.F18(N18) P801.F21(N21) P801.F24(N24) P801.F27(N27) P801.F30(N30) P801.F33(N33) P801.F36(N36) P801.F39(N39) P801.G1(N1) P801.G4(N4) P801.G5(N5) P801.G8(N8) P801.G11(N11) P801.G14(N14) P801.G17(N17) P801.G20(N20) P801.G23(N23) P801.G26(N26) P801.G29(N29) P801.G32(N32) P801.G35(N35) P801.G38(N38) P801.G40(N40) P801.H3(N3) P801.H6(N6) P801.H9(N9) P801.H12(N12) P801.H15(N15) P801.H18(N18) P801.H21(N21) P801.H24(N24) P801.H27(N27) P801.H30(N30) P801.H33(N33) P801.H36(N36) P801.H39(N39) P801.J1(N1) P801.J4(N4) P801.J5(N5) P801.J8(N8) P801.J11(N11) P801.J14(N14) P801.J17(N17) P801.J20(N20) P801.J23(N23) P801.J26(N26) P801.J29(N29) P801.J32(N32) P801.J35(N35) P801.J38(N38) P801.J40(N40) P801.K2(N2) P801.K3(N3) P801.K6(N6) P801.K9(N9) P801.K12(N12) P801.K15(N15) P801.K18(N18) P801.K21(N21) P801.K24(N24) P801.K27(N27) P801.K30(N30) P801.K33(N33) P801.K36(N36) P801.K39(N39) Q701.1(S1) Q701.4(S2) R203.2(N2) R212.2(N2) R220.2(N2) R228.2(N2) R236.2(N2) R401.1(N1) R402.1(N1) R403.1(N1) R404.2(N2) R409.1(N1) R417.1(N1) R418.2(N2) R419.2(N2) R428.2(N2) R504.2(N2) R505.1(N1) R506.2(N2) R507.2(N2) R508.2(N2) R509.2(N2) R514.2(N2) R515.2(N2) R516.2(N2) R517.2(N2) R518.2(N2) R525.1(N1) R603.2(N2) R605.1(N1) R607.1(N1) R609.1(N1) R611.1(N1) R613.1(N1) R701.1(N1) R706.2(N2) R710.2(N2) R713.2(N2) R714.2(N2) R718.1(N1) R719.1(N1) R720.1(N1) R724.1(N1) R728.1(N1) R732.2(N2) R733.2(N2) R734.2(N2) R737.2(N2) R740.1(N1) R801.1(N1) R819.1(N1) R821.1(N1) R823.1(N1) T200.5(GND) T201.5(GND) T202.5(GND) T203.5(GND) T204.5(GND) T305.5(GND) T306.5(GND) T307.2(GND1) T307.5(GND2) T308.2(GND1) T308.5(GND2) T309.5(GND) T310.5(GND) U101.A1(VSSA1) U101.A4(VSSA2) U101.A7(VSSA3) U101.A8(VSSA4) U101.A11(VSSA5) U101.A14(VSSA6) U101.B2(VSSA7) U101.B3(VSSA8) U101.B4(VSSA9) U101.B5(VSSA10) U101.B6(VSSA11) U101.B9(VSSA12) U101.B10(VSSA13) U101.B11(VSSA14) U101.B12(VSSA15) U101.B13(VSSA16) U101.C5(VSSA17) U101.C9(VSSA18) U101.C10(VSSA19) U101.D2(SNRXC-) U101.D3(SNRXB-) U101.D6(VSSA20) U101.D7(VSSA21) U101.D8(VSSA22) U101.D9(VSSA23) U101.E2(SNRXC+) U101.E3(SNRXB+) U101.E6(VSSA24) U101.E9(VSSA25) U101.E10(VSSA71) U101.F3(VSSA26) U101.F4(VSSA27) U101.F5(VSSA28) U101.F6(VSSA29) U101.F7(VSSA30) U101.F8(VSSA31) U101.F9(VSSA32) U101.F10(VSSA33) U101.G1(VSSA34) U101.G2(VSSA35) U101.G3(VSSA36) U101.G5(VSSA37) U101.G10(VSSA38) U101.G11(VSSA39) U101.G12(VSSA40) U101.G13(VSSA41) U101.G14(VSSA42) U101.H2(VSSA43) U101.H3(VSSA44) U101.H4(VSSA45) U101.H5(VSSA46) U101.H6(VSSA47) U101.H7(VSSA48) U101.H8(VSSA49) U101.H9(VSSA50) U101.H10(VSSA51) U101.H13(VSSA52) U101.J2(VSSA53) U101.J13(VSSA54) U101.K1(VSSA55) U101.K2(VSSA56) U101.K13(VSSA57) U101.K14(VSSA58) U101.L1(VSSA59) U101.L2(VSSA60) U101.L7(VSSD1) U101.L10(VSSD2) U101.L13(VSSA61) U101.L14(VSSA62) U101.M2(VSSA63) U101.M9(VSSA64) U101.N2(VSSA65) U101.N7(VSSA66) U101.N14(VSSA67) U101.P1(VSSA72) U101.P2(VSSA68) U101.P3(VSSA69) U101.P10(VSSA70) U401.4(REF_SEL) U401.9(NIC1) U401.13(NIC2) U401.PAD U402.2(GND) U403.4(GND) U404.3(GND) U405.7(GND) U601.6(GND1) U601.9(GND) U601.PAD U701.2(PGND3_1) U701.3(PGND3_2) U701.10(PGND4_1) U701.11(PGND4_2) U701.30(PGND) U701.PAD(EP) U702.4(GND) U702.PAD(EP) U801.4(VSS) U801.7(WC_N) Y401.3(GND) Y402.3(GND) Y403.2(GND)
VDD_IF: C415.2(N2) C417.2(N2) C419.2(N2) C642.1(N1) C643.1(N1) C734.2(N2) C735.2(N2) P504.1(N1) P707.1(N1) P801.J39(N39) P801.K40(N40) R502.1(N1) R503.1(N1) R510.1(N1) R511.1(N1) R512.1(N1) R513.1(N1) R606.1(N1) R738.2(N2) R739.2(N2) R808.1(N1) R809.1(N1) U101.M12(VDD_IF) U403.8(VCC) U404.1(VCCA) U404.4(EN) U405.1(VCCA) U405.8(EN) U702.1(VOUT1) U702.2(VOUT2)
VDD_IF_LDO: C733.2(N2) R736.2(N2) U702.5(EN) U702.7(VIN1) U702.8(VIN2)
VDDA_1P8_1: C327.1(N1) L306.1(N1) L341.2(N2) T306.2(GND_DC_FEED_RFGND) T310.2(GND_DC_FEED_RFGND)
VDDA_1P8_2: C322.1(N1) L305.1(N1) L340.2(N2) T305.2(GND_DC_FEED_RFGND) T309.2(GND_DC_FEED_RFGND)
VDDA_CALPLL: C614.1(N1) C615.1(N1) E602.2(N2) U101.G4(VDDA_CALPLL)
VDDA_CLK: C616.1(N1) C617.1(N1) E603.2(N2) U101.N1(VDDA_CLK)
VDDA_CLKSYNTH: C618.1(N1) C619.1(N1) E604.2(N2) U101.G6(VDDA_CLKSYNTH)
VDDA_DES: C652.1(N1) C653.1(N1) C654.1(N1) E613.2(N2) U101.N9(VDDA_DES) U101.P9(JESD_VTT_DES)
VDDA_RXLO: C620.1(N1) C621.1(N1) E605.2(N2) U101.C6(VDDA_RXLO)
VDDA_RXSYNTH: C622.1(N1) C623.1(N1) E606.2(N2) U101.G9(VDDA_RXSYNTH)
VDDA_RXTX: C608.1(N1) C609.1(N1) C610.1(N1) R601.2(N2) U101.F2(VDDA_RXTX)
VDDA_RXVCO: C624.1(N1) C625.1(N1) E607.2(N2) U101.C7(VDDA_RXVCO)
VDDA_SER: C611.1(N1) C612.1(N1) C613.1(N1) E601.2(N2) U101.N8(VDDA_SER) U101.P8(VDDA_SER1)
VDDA_SNRXSYNTH: C626.1(N1) C627.1(N1) E608.2(N2) U101.G7(VDDA_SNRXSYNTH)
VDDA_SNRXVCO: C628.1(N1) C629.1(N1) E609.2(N2) U101.C4(VDDA_SNRXVCO)
VDDA_TXLO: C634.1(N1) C635.1(N1) E612.2(N2) U101.F12(VDDA_TXLO)
VDDA_TXSYNTH: C632.1(N1) C633.1(N1) E611.2(N2) U101.G8(VDDA_TXSYNTH)
VDDA_TXVCO: C630.1(N1) C631.1(N1) E610.2(N2) U101.F11(VDDA_TXVCO)
1P3_BUCK_OUT: C716.2(N2) C725.1(N1) C726.1(N1) E702.1(N1) L701.2(N2) R705.1(N1) R722.2(N2)
3P3V_CLK: C414.2(N2) C416.2(N2) C418.2(N2) C420.1(N1) C421.2(N2) C422.2(N2) C423.2(N2) C424.2(N2) C425.2(N2) C426.2(N2) C427.2(N2) C428.2(N2) C429.2(N2) C430.2(N2) C431.2(N2) C432.2(N2) C433.2(N2) C434.2(N2) C435.2(N2) C436.2(N2) C437.2(N2) C438.2(N2) C439.2(N2) E705.2(N2) R416.1(N1) U401.1(VDD_1) U401.10(VDD_2) U401.16(VDD_3) U401.20(VDD_4) U401.27(VDD13) U401.30(VDD12) U401.33(VDD11) U401.36(VDD10) U401.39(VDD9) U401.42(VDD8) U401.45(VDD7) U401.48(VDD6) U401.51(VDD5) U401.54(VDD4) U401.60(VDD3) U401.63(VDD2) U401.66(VDD1) U401.69(VDD0) U401.72(VDD_5) U402.5(VCC) U404.6(VCCY) U405.14(VCCY)
3P3V_VCO: C405.2(N2) C738.2(N2) E706.2(N2) R408.2(N2) Y401.6(VDD) Y402.6(POS_VS) Y403.4(VDD)
3P3VAUX: C648.1(N1) C649.1(N1) C803.2(N2) C804.1(N1) P801.D32(N32) R818.2(N2) R820.2(N2) R822.2(N2) U601.10(VDD) U601.16(VDRIVE) U601.17(PD_N/RST_N) U801.8(VCC)
ADP5054_EN: P801.D1(N1) R702.1(N1)
ADP5054_VREG: C702.2(N2) R703.2(N2) U701.13(CFG34) U701.18(CFG12) U701.44(SYNC/MODE) U701.45(VREG)
AUXADC_0: C506.1(N1) P501.3(N3) U101.E13(AUXADC_0)
AUXADC_1: C505.1(N1) P501.4(N4) U101.C11(AUXADC_1)
AUXADC_2: C504.1(N1) P501.5(N5) U101.C12(AUXADC_2)
AUXADC_3: C503.1(N1) P501.6(N6) U101.D11(AUXADC_3)
BAL_TX1+: C303.1(N1) C309.2(N2) L303.2(N2) L305.2(N2) R309.2(N2) T305.3(BAL_OUT1) T309.3(BAL_OUT1)
BAL_TX1-: C303.2(N2) C310.2(N2) L303.1(N1) R310.2(N2) T305.4(BAL_OUT2) T309.4(BAL_OUT2)
BAL_TX2+: C304.1(N1) C317.2(N2) L304.2(N2) L306.2(N2) R317.2(N2) T306.3(BAL_OUT1) T310.3(BAL_OUT1)
BAL_TX2-: C304.2(N2) C318.2(N2) L304.1(N1) R318.2(N2) T306.4(BAL_OUT2) T310.4(BAL_OUT2)
BAL_TX_OUT1: C305.1(N1) R303.1(N1) T305.1(UNBAL_IN) T309.1(UNBAL_IN)
BAL_TX_OUT2: C306.1(N1) R304.1(N1) T306.1(UNBAL_IN) T310.1(UNBAL_IN)
CLK+: C402.2(N2) R406.1(N1) U401.2(REFA)
CLK-: C403.2(N2) R406.2(N2) U401.3(REFA_N)
CLK_RESETB: R416.2(N2) U401.19(RESET_N) U404.5(Y)
CLK_SYSREF_REQUEST: R417.2(N2) U401.57(SYSREF_REQ) U405.13(Y1)
COMP_OUT: R411.1(N1) Y401.5(COMP_OUT) Y402.5(NC)
DEV_CLK_IN+: C502.1(N1) R425.1(N1) R501.2(N2) U401.25(OUT13)
DEV_CLK_IN-: C501.1(N1) R425.2(N2) R501.1(N1) U401.26(OUT13_N)
DIR_CLK+: C402.1(N1) C409.1(N1) R403.2(N2) R405.1(N1) T401.1(N1)
DIR_CLK-: C403.1(N1) C407.1(N1) R404.1(N1) R405.2(N2) T401.3(N2)
EPROM_A0: P801.C34(N34) R818.1(N1) R819.2(N2) U601.11(AS0) U801.1(E0)
EPROM_A1: P801.D35(N35) R820.1(N1) R821.2(N2) U601.13(AS1) U801.2(E1)
FMC_CLK_RESETB: P801.D26(N26) U404.2(A)
FMC_SYSREF_REQUEST: P801.D27(N27) U405.2(A1)
FMCA_SCL: P801.C30(N30) U601.15(SCL) U801.6(SCL)
FMCA_SDA: P801.C31(N31) U601.14(SDA) U801.5(SDA)
FMCA_VADJ: C732.1(N1) P801.E39(N39) P801.F40(N40) P801.G39(N39) P801.H40(N40) R738.1(N1) TP812.1(N1)
FMCA_VCC_3P3V: P801.C39(N39) P801.D36(N36) P801.D38(N38) P801.D40(N40) TP816.1(N1)
FMCA_VCC_12P0V: F701.1(N1) P801.C35(N35) P801.C37(N37) TP815.1(N1)
FPGA_AUX_CLK+: C805.1(N1) R429.1(N1) U401.61(OUT2)
FPGA_AUX_CLK-: C806.1(N1) R429.2(N2) U401.62(OUT2_N)
FPGA_REF_CLK+: C801.2(N2) R422.1(N1) U401.64(OUT1)
FPGA_REF_CLK-: C802.2(N2) R422.2(N2) U401.65(OUT1_N)
FPGA_SYSREF+: P801.G36(N36) R423.2(N2) U401.58(OUT3)
FPGA_SYSREF-: P801.G37(N37) R423.1(N1) U401.59(OUT3_N)
GP_INTERRUPT: R803.1(N1) TP803.1(N1) U101.J5(GP_INTERRUPT)
GPIO_0: P502.2(N2) P801.H19(N19) R513.2(N2) R517.1(N1) U101.K8(GPIO_0)
GPIO_1: P502.3(N3) P801.H20(N20) R512.2(N2) R516.1(N1) U101.J8(GPIO_1)
GPIO_2: P502.4(N4) P801.G18(N18) R511.2(N2) R515.1(N1) U101.J7(GPIO_2)
GPIO_3: P502.5(N5) P801.G19(N19) R510.2(N2) R514.1(N1) U101.K7(GPIO_3)
GPIO_3P3_0: C523.1(N1) P503.5(N3) U101.C1(GPIO_3P3_0)
GPIO_3P3_1: C524.1(N1) P503.7(N4) U101.C2(GPIO_3P3_1)
GPIO_3P3_2: P503.9(N5) U101.F1(GPIO_3P3_2)
GPIO_3P3_3: C525.1(N1) P503.11(N6) U101.D1(GPIO_3P3_3)
GPIO_3P3_4: C526.1(N1) P503.13(N7) U101.E1(GPIO_3P3_4)
GPIO_3P3_5: C527.1(N1) P503.15(N8) U101.D5(GPIO_3P3_5)
GPIO_3P3_6: C528.1(N1) P503.2(N1) U101.E14(GPIO_3P3_6)
GPIO_3P3_7: C529.1(N1) P503.4(N2) U101.D12(GPIO_3P3_7)
GPIO_3P3_8: C530.1(N1) P503.6(N3) U101.D13(GPIO_3P3_8)
GPIO_3P3_9: C531.1(N1) P503.8(N4) U101.C13(GPIO_3P3_9)
GPIO_3P3_10: C532.1(N1) P503.10(N5) U101.D14(GPIO_3P3_10)
GPIO_3P3_11: P503.12(N6) U101.F14(GPIO_3P3_11)
GPIO_4: P502.6(N6) P801.H25(N25) R524.1(N1) U101.K6(GPIO_4)
GPIO_5: P502.7(N7) P801.H26(N26) R522.1(N1) U101.K5(GPIO_5)
GPIO_6: P502.8(N8) P801.C22(N22) R523.1(N1) U101.L5(GPIO_6)
GPIO_7: P502.9(N9) P801.C23(N23) R519.1(N1) U101.L6(GPIO_7)
GPIO_8: P502.10(N10) P801.G25(N25) R520.1(N1) U101.L12(GPIO_8)
GPIO_9: P502.11(N11) P801.H22(N22) U101.K12(GPIO_9)
GPIO_10: P502.12(N12) P801.H23(N23) U101.J12(GPIO_10)
GPIO_11: P502.13(N13) P801.G21(N21) U101.H12(GPIO_11)
GPIO_12: P502.14(N14) P801.G22(N22) U101.H11(GPIO_12)
GPIO_13: P502.15(N15) P801.G31(N31) U101.J11(GPIO_13)
GPIO_14: P502.16(N16) P801.G30(N30) U101.K11(GPIO_14)
GPIO_15: P502.17(N17) P801.G24(N24) U101.L11(GPIO_15)
GPIO_16: P502.18(N18) P801.G16(N16) U101.M11(GPIO_16)
GPIO_17: P502.19(N19) P801.G15(N15) U101.M10(GPIO_17)
GPIO_18: P502.20(N20) P801.D12(N12) R518.1(N1) R521.1(N1) U101.J3(GPIO_18)
INPUT_VOLTAGE: C701.1(N1) C705.1(N1) C707.1(N1) C709.1(N1) CR701.C(N) DS701.A(P) R602.2(N2) R709.1(N1) U701.6(PVIN3) U701.7(PVIN4) U701.22(PVIN2_1) U701.23(PVIN2_2) U701.24(PVIN2_3) U701.36(PVIN1_1) U701.37(PVIN1_2) U701.38(PVIN1_3)
JTAG_TDI: P801.D30(N30) R815.2(N2)
JTAG_TDO: P801.D31(N31) R815.1(N1)
LDO_VCO_2P5: C412.1(N1) C413.1(N1) U401.15(LDO_VCO)
LF_EXT_CAP: C410.2(N2) R415.2(N2) U401.7(LF1)
LF_PLL2: C412.2(N2) U401.14(LF2_CAP)
ORX1+: C231.2(N2) C232.2(N2) L231.1(N1) L232.1(N1) R231.2(N2) U101.A12(ORX1+)
ORX1-: C230.2(N2) C232.1(N1) L230.1(N1) L232.2(N2) R230.2(N2) U101.A13(ORX1-)
ORX2+: C239.2(N2) C240.2(N2) L239.1(N1) L240.1(N1) R239.2(N2) U101.A2(ORX2+)
ORX2-: C238.2(N2) C240.1(N1) L238.1(N1) L240.2(N2) R238.2(N2) U101.A3(ORX2-)
OUT: R410.1(N1) Y401.4(OUT) Y402.4(OUTPUT) Y403.3(OUT)
RESETB: R502.2(N2) R802.1(N1) TP804.1(N1) U101.J4(RESETB)
RX1+: C205.2(N2) C207.1(N1) L205.1(N1) L207.1(N1) R205.2(N2) U101.A9(RX1+)
RX1-: C206.2(N2) C207.2(N2) L206.1(N1) L207.2(N2) R206.2(N2) U101.A10(RX1-)
RX1_ENABLE: P501.7(N7) R508.1(N1) R814.1(N1) U101.M5(RX1_ENABLE)
RX2+: C214.2(N2) C216.1(N1) L214.1(N1) L216.1(N1) R214.2(N2) U101.A5(RX2+)
RX2-: C215.2(N2) C216.2(N2) L215.1(N1) L216.2(N2) R215.2(N2) U101.A6(RX2-)
RX2_ENABLE: P501.8(N8) R509.1(N1) R817.1(N1) U101.M7(RX2_ENABLE)
RX_EXTLO+: C332.2(N2) U101.B8(RX_EXTLO+)
RX_EXTLO-: C333.2(N2) U101.B7(RX_EXTLO-)
SERDIN0+: C508.1(N1) P801.A26(N26)
SERDIN0-: C507.1(N1) P801.A27(N27)
SERDIN1+: C510.1(N1) P801.C2(N2)
SERDIN1-: C509.1(N1) P801.C3(N3)
SERDIN2+: C512.1(N1) P801.A30(N30)
SERDIN2-: C511.1(N1) P801.A31(N31)
SERDIN3+: C514.1(N1) P801.A22(N22)
SERDIN3-: C513.1(N1) P801.A23(N23)
SERDOUT0+: C516.1(N1) P801.A2(N2)
SERDOUT0-: C515.1(N1) P801.A3(N3)
SERDOUT1+: C518.1(N1) P801.A6(N6)
SERDOUT1-: C517.1(N1) P801.A7(N7)
SERDOUT2+: C520.1(N1) P801.C6(N6)
SERDOUT2-: C519.1(N1) P801.C7(N7)
SERDOUT3+: C522.1(N1) P801.A10(N10)
SERDOUT3-: C521.1(N1) P801.A11(N11)
SNRXA+: C222.2(N2) C224.1(N1) L222.1(N1) L224.1(N1) R222.2(N2) U101.E4(SNRXA+)
SNRXA-: C223.2(N2) C224.2(N2) L223.1(N1) L224.2(N2) R223.2(N2) U101.D4(SNRXA-)
SPI_CLK: R804.1(N1) TP802.1(N1) U101.K9(SCLK) U405.3(A2)
SPI_CLK_9528: U401.22(SCLK/SCL) U405.12(Y2)
SPI_CS0: R808.2(N2) R811.1(N1) TP813.1(N1) U101.K10(CSB) U403.7(OE2_N)
SPI_CS1: R809.2(N2) R812.1(N1) TP814.1(N1) U403.1(OE1_N) U405.5(A4)
SPI_CS_9528: U401.21(CS_N) U405.10(Y4)
SPI_DIN: R805.1(N1) TP801.1(N1) U101.J9(SDIO) U405.4(A3)
SPI_DIN_9528: U401.23(SDIO/SDA) U405.11(Y3)
SPI_DOUT: R806.1(N1) TP809.1(N1) U403.3(Y2) U403.6(Y1)
SPI_DOUT_9370: R427.2(N2) TP402.1(N1) U101.J10(SDO)
SPI_DOUT_9528: R426.2(N2) TP401.1(N1) U401.24(SDO)
STATUS_0: R418.1(N1) U401.55(STATUS0/SP0) U402.1(A1)
STATUS_1: R419.1(N1) U401.56(STATUS1/SP1) U402.3(A2)
SYNCINB0+: P801.G9(N9) TP807.1(N1) U101.M4(SYNCINB0+)
SYNCINB0-: P801.G10(N10) TP808.1(N1) U101.M3(SYNCINB0-)
SYNCINB1+: P801.G27(N27) TP810.1(N1) U101.L4(SYNCINB1+)
SYNCINB1-: P801.G28(N28) TP811.1(N1) U101.L3(SYNCINB1-)
SYNCOUTB0+: P801.H7(N7) TP805.1(N1) U101.M13(SYNCOUTB0+)
SYNCOUTB0-: P801.H8(N8) TP806.1(N1) U101.M14(SYNCOUTB0-)
SYSREF_IN+: R424.2(N2) U101.K3(SYSREF_IN+) U401.28(OUT12)
SYSREF_IN-: R424.1(N1) U101.K4(SYSREF_IN-) U401.29(OUT12_N)
TEST: R503.2(N2) R504.1(N1) R810.1(N1) U101.J6(TEST)
TRI_STATE: R408.1(N1) R409.2(N2) Y401.2(TRI_STATE) Y402.2(ENABLE_DISABLE)
TX1+: C309.1(N1) C311.1(N1) L307.1(N1) L311.2(N2) R309.1(N1) U101.H14(TX1+)
TX1-: C310.1(N1) C311.2(N2) L308.2(N2) L311.1(N1) R310.1(N1) U101.J14(TX1-)
TX1_ENABLE: P501.9(N9) R507.1(N1) R813.1(N1) U101.M6(TX1_ENABLE)
TX2+: C317.1(N1) C319.1(N1) L315.1(N1) L319.2(N2) R317.1(N1) U101.J1(TX2+)
TX2-: C318.1(N1) C319.2(N2) L316.2(N2) L319.1(N1) R318.1(N1) U101.H1(TX2-)
TX2_ENABLE: P501.10(N10) R506.1(N1) R816.1(N1) U101.M8(TX2_ENABLE)
TX_EXTLO+: C336.2(N2) U101.E12(TX_EXTLO+)
TX_EXTLO-: C337.2(N2) U101.E11(TX_EXTLO-)
UNNAMED_3_CAP_I2_N1: C204.2(N2) C206.1(N1) L204.2(N2) L206.2(N2) R206.1(N1) T200.4(BAL_OUT2)
UNNAMED_3_CAP_I3_N1: C204.1(N1) C205.1(N1) L204.1(N1) L205.2(N2) R205.1(N1) T200.3(BAL_OUT1)
UNNAMED_3_CAP_I11_N1: C200.1(N1) C201.1(N1) J200.1(CNTR) L200.2(N2) L201.2(N2) R201.1(N1)
UNNAMED_3_CAP_I74_N2: C201.2(N2) C202.1(N1) C245.1(N1) L201.1(N1) L202.2(N2) R201.2(N2) R202.1(N1)
UNNAMED_3_CAP_I79_N1: C203.1(N1) R203.1(N1) T200.2(GND_DC_FEED_RFGND)
UNNAMED_3_CAP_I109_N1: C213.1(N1) C214.1(N1) L213.1(N1) L214.2(N2) R214.1(N1) T201.3(BAL_OUT1)
UNNAMED_3_CAP_I109_N2: C213.2(N2) C215.1(N1) L213.2(N2) L215.2(N2) R215.1(N1) T201.4(BAL_OUT2)
UNNAMED_3_CAP_I115_N1: C208.1(N1) C209.1(N1) J201.1(CNTR) L208.2(N2) L209.2(N2) R209.1(N1)
UNNAMED_3_CAP_I115_N2: C209.2(N2) C211.1(N1) C241.1(N1) L209.1(N1) L211.2(N2) R204.1(N1) R209.2(N2)
UNNAMED_3_CAP_I126_N1: C217.1(N1) C218.1(N1) J202.1(CNTR) L217.2(N2) L218.2(N2) R218.1(N1)
UNNAMED_3_CAP_I126_N2: C218.2(N2) C219.1(N1) C242.1(N1) L218.1(N1) L219.2(N2) R207.1(N1) R218.2(N2)
UNNAMED_3_CAP_I127_N1: C220.1(N1) R220.1(N1) T202.2(GND_DC_FEED_RFGND)
UNNAMED_3_CAP_I137_N1: C221.1(N1) C222.1(N1) L221.1(N1) L222.2(N2) R222.1(N1) T202.4(BAL_OUT2)
UNNAMED_3_CAP_I137_N2: C221.2(N2) C223.1(N1) L221.2(N2) L223.2(N2) R223.1(N1) T202.3(BAL_OUT1)
UNNAMED_3_CAP_I141_N1: C229.1(N1) C230.1(N1) L229.2(N2) L230.2(N2) R230.1(N1) T203.3(BAL_OUT1)
UNNAMED_3_CAP_I141_N2: C229.2(N2) C231.1(N1) L229.1(N1) L231.2(N2) R231.1(N1) T203.4(BAL_OUT2)
UNNAMED_3_CAP_I162_N1: C225.1(N1) C226.1(N1) J203.1(CNTR) L225.2(N2) L226.2(N2) R226.1(N1)
UNNAMED_3_CAP_I162_N2: C226.2(N2) C227.1(N1) C243.1(N1) L226.1(N1) L227.2(N2) R208.1(N1) R226.2(N2)
UNNAMED_3_CAP_I167_N1: C228.1(N1) R228.1(N1) T203.2(GND_DC_FEED_RFGND)
UNNAMED_3_CAP_I173_N1: C233.1(N1) C234.1(N1) J204.1(CNTR) L233.2(N2) L234.2(N2) R234.1(N1)
UNNAMED_3_CAP_I173_N2: C234.2(N2) C235.1(N1) C244.1(N1) L234.1(N1) L235.2(N2) R210.1(N1) R234.2(N2)
UNNAMED_3_CAP_I178_N2: C236.2(N2) R236.1(N1) T204.2(GND_DC_FEED_RFGND)
UNNAMED_3_CAP_I188_N1: C237.1(N1) C238.1(N1) L237.2(N2) L238.2(N2) R238.1(N1) T204.3(BAL_OUT1)
UNNAMED_3_CAP_I188_N2: C237.2(N2) C239.1(N1) L237.1(N1) L239.2(N2) R239.1(N1) T204.4(BAL_OUT2)
UNNAMED_3_CAP_I191_N1: C212.1(N1) R212.1(N1) T201.2(GND_DC_FEED_RFGND)
UNNAMED_3_CAP_I192_N2: C245.2(N2) R202.2(N2) T200.1(UNBAL_IN)
UNNAMED_3_CAP_I194_N2: C241.2(N2) R204.2(N2) T201.1(UNBAL_IN)
UNNAMED_3_CAP_I197_N2: C242.2(N2) R207.2(N2) T202.1(UNBAL_IN)
UNNAMED_3_CAP_I199_N2: C243.2(N2) R208.2(N2) T203.1(UNBAL_IN)
UNNAMED_3_CAP_I201_N2: C244.2(N2) R210.2(N2) T204.1(UNBAL_IN)
UNNAMED_4_CAP_I388_N1: C333.1(N1) T307.4(BAL2)
UNNAMED_4_CAP_I389_N1: C332.1(N1) T307.3(BAL1)
UNNAMED_4_CAP_I525_N1: C301.1(N1) C305.2(N2) C323.1(N1) L301.2(N2) L323.2(N2) R301.1(N1) R303.2(N2)
UNNAMED_4_CAP_I526_N1: C301.2(N2) C324.1(N1) J305.1(CNTR) L301.1(N1) L324.2(N2) R301.2(N2)
UNNAMED_4_CAP_I531_N1: C302.2(N2) C329.1(N1) J306.1(CNTR) L302.1(N1) L329.2(N2) R302.2(N2)
UNNAMED_4_CAP_I533_N1: C302.1(N1) C306.2(N2) C328.1(N1) L302.2(N2) L328.2(N2) R302.1(N1) R304.2(N2)
UNNAMED_4_CAP_I561_N1: C331.1(N1) R312.2(N2) T307.1(UNBAL)
UNNAMED_4_CAP_I563_N1: C330.1(N1) J307.1(CNTR) R312.1(N1)
UNNAMED_4_CAP_I601_N1: C335.1(N1) R313.2(N2) T308.1(UNBAL)
UNNAMED_4_CAP_I603_N1: C334.1(N1) J308.1(CNTR) R313.1(N1)
UNNAMED_4_CAP_I696_N1: C336.1(N1) T308.3(BAL1)
UNNAMED_4_CAP_I697_N1: C337.1(N1) T308.4(BAL2)
UNNAMED_5_CAP_I803_N2: C411.2(N2) R415.1(N1)
UNNAMED_5_CAP_I900_N2: C406.2(N2) R412.1(N1) R413.2(N2) R428.1(N1)
UNNAMED_5_CAP_I905_N1: C401.1(N1) J401.1(CNTR) R401.2(N2)
UNNAMED_5_CAP_I905_N2: C401.2(N2) T401.4(N3)
UNNAMED_5_CAP_I916_N1: C408.1(N1) R411.2(N2) R413.1(N1)
UNNAMED_5_CMOSNC7WV125K8X_I90_1: R427.1(N1) U403.5(A2)
UNNAMED_5_CMOSNC7WV125K8X_I90_A: R426.1(N1) U403.2(A1)
UNNAMED_5_DIOLED_I865_P: D401.A(P) R420.2(N2)
UNNAMED_5_DIOLED_I866_P: D402.A(P) R421.2(N2)
UNNAMED_5_NC7WZ17P6X_I868_Y1: R421.1(N1) U402.6(Y1)
UNNAMED_5_NC7WZ17P6X_I868_Y2: R420.1(N1) U402.4(Y2)
UNNAMED_5_RES_I897_N2: R410.2(N2) R412.2(N2) R414.1(N1)
UNNAMED_5_RES_I907_N2: R402.2(N2) T401.5(N4)
UNNAMED_6_AD9370V2_I826_DEVCL_1: C502.2(N2) U101.E7(DEV_CLK_IN+)
UNNAMED_6_AD9370V2_I826_DEVCLKI: C501.2(N2) U101.E8(DEV_CLK_IN-)
UNNAMED_6_AD9370V2_I826_RBIAS: R505.2(N2) U101.C14(RBIAS)
UNNAMED_6_AD9370V2_I832_SERDI_1: C507.2(N2) U101.P11(SERDIN0-)
UNNAMED_6_AD9370V2_I832_SERDI_2: C509.2(N2) U101.P13(SERDIN1-)
UNNAMED_6_AD9370V2_I832_SERDI_3: C511.2(N2) U101.N10(SERDIN2-)
UNNAMED_6_AD9370V2_I832_SERDI_4: C514.2(N2) U101.N13(SERDIN3+)
UNNAMED_6_AD9370V2_I832_SERDIN0: C508.2(N2) U101.P12(SERDIN0+)
UNNAMED_6_AD9370V2_I832_SERDIN1: C510.2(N2) U101.P14(SERDIN1+)
UNNAMED_6_AD9370V2_I832_SERDIN2: C512.2(N2) U101.N11(SERDIN2+)
UNNAMED_6_AD9370V2_I832_SERDIN3: C513.2(N2) U101.N12(SERDIN3-)
UNNAMED_6_AD9370V2_I832_SERDO_1: C515.2(N2) U101.P6(SERDOUT0-)
UNNAMED_6_AD9370V2_I832_SERDO_2: C517.2(N2) U101.P4(SERDOUT1-)
UNNAMED_6_AD9370V2_I832_SERDO_3: C518.2(N2) U101.P5(SERDOUT1+)
UNNAMED_6_AD9370V2_I832_SERDO_4: C519.2(N2) U101.N5(SERDOUT2-)
UNNAMED_6_AD9370V2_I832_SERDO_5: C520.2(N2) U101.N6(SERDOUT2+)
UNNAMED_6_AD9370V2_I832_SERDO_6: C522.2(N2) U101.N4(SERDOUT3+)
UNNAMED_6_AD9370V2_I832_SERDO_7: C521.2(N2) U101.N3(SERDOUT3-)
UNNAMED_6_AD9370V2_I832_SERDOUT: C516.2(N2) U101.P7(SERDOUT0+)
UNNAMED_6_CN20PV2_I813_N6: P504.11(N6) TP502.1(N1)
UNNAMED_6_CN20PV2_I813_N7: P504.13(N7) TP501.1(N1)
UNNAMED_6_CN20PV2_I813_N9: P504.17(N9) R525.2(N2)
UNNAMED_6_CN20PV2_I814_N1: P504.2(N1) R519.2(N2)
UNNAMED_6_CN20PV2_I814_N2: P504.4(N2) R520.2(N2) R521.2(N2)
UNNAMED_6_CN20PV2_I814_N3: P504.6(N3) R522.2(N2)
UNNAMED_6_CN20PV2_I814_N4: P504.8(N4) R523.2(N2)
UNNAMED_6_CN20PV2_I814_N8: P504.16(N8) R524.2(N2)
UNNAMED_7_AD7291_I1067_DCAP: C651.1(N1) U601.8(DCAP)
UNNAMED_7_AD7291_I1067_VIN0: R602.1(N1) R603.1(N1) U601.18(VIN0)
UNNAMED_7_AD7291_I1067_VIN1: R604.2(N2) R605.2(N2) U601.19(VIN1)
UNNAMED_7_AD7291_I1067_VIN2: R606.2(N2) R607.2(N2) U601.20(VIN2)
UNNAMED_7_AD7291_I1067_VIN3: R608.2(N2) R609.2(N2) U601.1(VIN3)
UNNAMED_7_AD7291_I1067_VIN5: R610.2(N2) R611.2(N2) U601.3(VIN5)
UNNAMED_7_AD7291_I1067_VIN7: R612.2(N2) R613.2(N2) U601.5(VIN7)
UNNAMED_7_AD7291_I1067_VREF: C650.1(N1) U601.7(VREF)
UNNAMED_7_AD9370V2_I936_VCLKVCO: C644.1(N1) U101.M1(VCLK_VCO_LDO)
UNNAMED_7_AD9370V2_I936_VDDABB: C604.1(N1) C606.1(N1) R614.1(N1) U101.E5(VDDA_BB)
UNNAMED_7_AD9370V2_I936_VDDARXR: C603.1(N1) C605.1(N1) R615.1(N1) U101.B1(VDDA_RXRF)
UNNAMED_7_AD9370V2_I936_VRXVCOL: C645.1(N1) U101.C8(VRX_VCO_LDO)
UNNAMED_7_AD9370V2_I936_VSNRXVC: C646.1(N1) U101.C3(VSNRX_VCO_LDO)
UNNAMED_7_AD9370V2_I936_VTXVCOL: C647.1(N1) U101.F13(VTX_VCO_LDO)
UNNAMED_8_ADP125_I911_ADJ: R739.1(N1) R740.2(N2) U702.3(ADJ)
UNNAMED_8_ADP5054_I118_BST1: C713.1(N1) U701.32(BST1)
UNNAMED_8_ADP5054_I118_BST2: C715.2(N2) U701.28(BST2)
UNNAMED_8_ADP5054_I118_BST3: C717.1(N1) U701.1(BST3)
UNNAMED_8_ADP5054_I118_BST4: C719.1(N1) U701.12(BST4)
UNNAMED_8_ADP5054_I118_COMP1: R704.2(N2) U701.40(COMP1)
UNNAMED_8_ADP5054_I118_COMP2: R707.2(N2) U701.20(COMP2)
UNNAMED_8_ADP5054_I118_COMP3: R708.2(N2) U701.47(COMP3)
UNNAMED_8_ADP5054_I118_COMP4: R711.2(N2) U701.15(COMP4)
UNNAMED_8_ADP5054_I118_DL1: Q701.5(G2) R718.2(N2) U701.31(DL1)
UNNAMED_8_ADP5054_I118_DL2: Q701.2(G1) R719.2(N2) U701.29(DL2)
UNNAMED_8_ADP5054_I118_EN1: C711.2(N2) P702.2(N2) R705.2(N2) R706.1(N1) U701.14(EN4) U701.39(EN1)
UNNAMED_8_ADP5054_I118_EN2: P702.1(N1) R702.2(N2) R703.1(N1) U701.21(EN2)
UNNAMED_8_ADP5054_I118_EN3: C712.2(N2) P702.3(N3) R709.2(N2) R710.1(N1) R712.1(N1) U701.48(EN3)
UNNAMED_8_ADP5054_I118_FB1: R714.1(N1) R715.1(N1) R716.1(N1) R717.1(N1) U701.41(FB1)
UNNAMED_8_ADP5054_I118_FB2: R720.2(N2) R721.1(N1) R722.1(N1) R723.1(N1) U701.19(FB2)
UNNAMED_8_ADP5054_I118_FB3: R724.2(N2) R725.1(N1) R726.1(N1) R727.1(N1) U701.46(FB3)
UNNAMED_8_ADP5054_I118_FB4: R728.2(N2) R729.1(N1) R730.1(N1) R731.1(N1) U701.16(FB4)
UNNAMED_8_ADP5054_I118_PWRGD: R712.2(N2) U701.17(PWRGD)
UNNAMED_8_ADP5054_I118_RT: R713.1(N1) U701.42(RT)
UNNAMED_8_ADP5054_I118_SW11: C713.2(N2) L700.1(N1) Q701.3(D2) Q701.PAD2(D2_1) U701.33(SW1_1) U701.34(SW1_2) U701.35(SW1_3)
UNNAMED_8_ADP5054_I118_SW21: C715.1(N1) L701.1(N1) Q701.6(D1) Q701.PAD1(D1_1) U701.25(SW2_1) U701.26(SW2_2) U701.27(SW2_3)
UNNAMED_8_ADP5054_I118_SW31: C717.2(N2) L702.1(N1) U701.4(SW3_1) U701.5(SW3_2)
UNNAMED_8_ADP5054_I118_SW41: C719.2(N2) L703.1(N1) U701.8(SW4_1) U701.9(SW4_2)
UNNAMED_8_ADP5054_I118_VDD: C703.2(N2) U701.43(VDD)
UNNAMED_8_CAP_I101_N1: C714.2(N2) C721.1(N1) C722.1(N1) C723.1(N1) E701.1(N1) L700.2(N2) R717.2(N2)
UNNAMED_8_CAP_I809_N2: C724.2(N2) R732.1(N1)
UNNAMED_8_CAP_I814_N2: C727.2(N2) R733.1(N1)
UNNAMED_8_CAP_I872_N2: C731.2(N2) R737.1(N1)
UNNAMED_8_CAP_I936_N2: C729.2(N2) R734.1(N1)
UNNAMED_8_CAP_I945_N1: C720.2(N2) C730.1(N1) E704.1(N1) L703.2(N2) R730.2(N2)
UNNAMED_8_CAP_I967_N1: C720.1(N1) R729.2(N2)
UNNAMED_8_CAP_I970_N1: C718.1(N1) R725.2(N2)
UNNAMED_8_CAP_I971_N1: C716.1(N1) R721.2(N2)
UNNAMED_8_CAP_I974_N1: C714.1(N1) R715.2(N2)
UNNAMED_8_CAP_I985_N2: C704.2(N2) R704.1(N1)
UNNAMED_8_CAP_I986_N2: C706.2(N2) R707.1(N1)
UNNAMED_8_CAP_I989_N2: C708.2(N2) R708.1(N1)
UNNAMED_8_CAP_I990_N2: C710.2(N2) R711.1(N1)
UNNAMED_8_CAP_I1036_N1: C718.2(N2) C728.1(N1) C739.1(N1) E703.1(N1) L702.2(N2) R726.2(N2)
UNNAMED_8_CN2P_I1027_N1: F702.1(N1) P701.1(N1)
UNNAMED_8_DIO_I32_P: CR701.A(P) F701.2(N2) F702.2(N2)
UNNAMED_8_DIOLED_I983_N: DS701.C(N) R701.2(N2)
UNNAMED_8_DIOLED_I1004_P: DS702.A(P) R735.2(N2)
UNNAMED_9_CAP_I337_N1: C801.1(N1) P801.B20(N20)
UNNAMED_9_CAP_I338_N1: C802.1(N1) P801.B21(N21)
UNNAMED_9_CAP_I852_N2: C806.2(N2) P801.D5(N5)
UNNAMED_9_CAP_I853_N2: C805.2(N2) P801.D4(N4)
UNNAMED_9_CN400PAK_I293_N2: P801.H2(N2) R801.2(N2)
UNNAMED_9_CN400PAK_I293_N10: P801.H10(N10) R802.2(N2)
UNNAMED_9_CN400PAK_I293_N11: P801.H11(N11) R803.2(N2)
UNNAMED_9_CN400PAK_I293_N13: P801.H13(N13) R804.2(N2)
UNNAMED_9_CN400PAK_I293_N14: P801.H14(N14) R805.2(N2)
UNNAMED_9_CN400PAK_I296_N12: P801.G12(N12) R806.2(N2)
UNNAMED_9_CN400PAK_I297_N18: P801.C18(N18) R816.2(N2)
UNNAMED_9_CN400PAK_I297_N19: P801.C19(N19) R817.2(N2)
UNNAMED_9_CN400PAK_I298_N11: P801.D11(N11) R810.2(N2)
UNNAMED_9_CN400PAK_I298_N14: P801.D14(N14) R811.2(N2)
UNNAMED_9_CN400PAK_I298_N15: P801.D15(N15) R812.2(N2)
UNNAMED_9_CN400PAK_I298_N17: P801.D17(N17) R813.2(N2)
UNNAMED_9_CN400PAK_I298_N18: P801.D18(N18) R814.2(N2)
UNNAMED_9_CN400PAK_I299_N1: P801.F1(N1) R807.2(N2)
UNNAMED_9_ICM24CXX_I809_E2: R822.1(N1) R823.2(N2) U801.3(E2)
VCON: C404.1(N1) R407.2(N2) Y401.1(VCON) Y402.1(VCNTRL) Y403.1(CONTROL)
VCXO_CTRL: R407.1(N1) U401.8(VCXO_VT)
VCXO_IN+: C408.2(N2) C409.2(N2) U401.11(VCXO_IN)
VCXO_IN-: C407.2(N2) R414.2(N2) U401.12(VCXO_IN_N)
VOUT1_1V3_ANLG: C601.1(N1) C602.1(N1) C724.1(N1) E601.1(N1) E602.1(N1) E603.1(N1) E604.1(N1) E605.1(N1) E606.1(N1) E607.1(N1) E608.1(N1) E609.1(N1) E610.1(N1) E611.1(N1) E612.1(N1) E613.1(N1) E701.2(N2) P703.1(N1) R601.1(N1) R612.1(N1) R614.2(N2) R615.2(N2) R716.2(N2)
VOUT2_1V3_DIG: C636.1(N1) C637.1(N1) C638.1(N1) C639.1(N1) C727.1(N1) E702.2(N2) P704.1(N1) R604.1(N1) R723.2(N2) U101.L8(VDIG) U101.L9(VDIG1)
VOUT3_3V3: C641.1(N1) C729.1(N1) C736.1(N1) C737.2(N2) E703.2(N2) E705.1(N1) E706.1(N1) P705.1(N1) R608.1(N1) R727.2(N2) R735.1(N1) R736.1(N1) R807.1(N1) U101.B14(VDDA_3P3)
VOUT4_1V8: C307.1(N1) C308.1(N1) C315.1(N1) C316.1(N1) C320.1(N1) C321.1(N1) C325.1(N1) C326.1(N1) C640.1(N1) C731.1(N1) E704.2(N2) L307.2(N2) L308.1(N1) L315.2(N2) L316.1(N1) L340.1(N1) L341.1(N1) P706.1(N1) R610.1(N1) R731.2(N2) U101.D10(VDDA_1P8)

Pads without a net: P504 7 10 12 14 18 20; P801 A14 A15 A18 A19 A34 A35 A38 A39 B1 B4 B5 B8 B9 B12 B13 B16 B17 B24 B25 B28 B29 B32 B33 B36 B37 B40 C10 C11 C14 C15 C26 C27 D8 D9 D20 D21 D23 D24 D29 D33 D34 E2 E3 E6 E7 E9 E10 E12 E13 E15 E16 E18 E19 E21 E22 E24 E25 E27 E28 E30 E31 E33 E34 E36 E37 F4 F5 F7 F8 F10 F11 F13 F14 F16 F17 F19 F20 F22 F23 F25 F26 F28 F29 F31 F32 F34 F35 F37 F38 G2 G3 G6 G7 G13 G33 G34 H1 H4 H5 H16 H17 H28 H29 H31 H32 H34 H35 H37 H38 J2 J3 J6 J7 J9 J10 J12 J13 J15 J16 J18 J19 J21 J22 J24 J25 J27 J28 J30 J31 J33 J34 J36 J37 K1 K4 K5 K7 K8 K10 K11 K13 K14 K16 K17 K19 K20 K22 K23 K25 K26 K28 K29 K31 K32 K34 K35 K37 K38; T200 6; T201 6; T202 6; T203 6; T204 6; T305 6; T306 6; T307 6; T308 6; T309 6; T310 6; T401 2; U401 5 6 17 18 31 32 34 35 37 38 40 41 43 44 46 47 49 50 52 53 67 68 70 71; U405 6 9; U601 2 4 12; U702 6

## Via types
v1: diameter 0.508, hole 0.254, TOP to BOTTOM, 1130 vias
v2: diameter 0.406, hole 0.203, TOP to BOTTOM, 271 vias
v3: diameter 0.508, hole 0.255, L11_GND to BOTTOM, 88 vias
v4: diameter 0.406, hole 0.203, L11_GND to BOTTOM, 17 vias
v5: diameter 0.305, hole 0.152, TOP to BOTTOM, 90 vias
v6: diameter 0.305, hole 0.153, TOP to L10_SIG, 110 vias
v7: diameter 1.016, hole 0.508, TOP to BOTTOM, 9 vias
v8: diameter 0.508, hole 0.254, TOP to L10_SIG, 60 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
AGND: length 1420.9
  TOP w0.127: C200.2 13.88,53.6 ; C324.2 L324.1 ; L202.1 C202.2 ; C323.2 L323.1 ; L328.1 C328.2 ; L211.1 C211.2 ; L329.1 C329.2 ; C208.2 L208.1
  TOP w0.203: C322.2 32.46,58.58 ; 34.33,28.03 C329.2 ; 37.22,34.97 C327.2
  TOP w0.254: v5(28.44,44.38) U101.A4 v5(29.24,43.58) ; v5(34.04,51.58) U101.H13 v5(34.84,51.58) U101.J13 v5(35.64,51.58) ; v5(34.04,51.58) U101.G14 33.19,52.43 v6(33.19,52.59) ; v5(34.04,51.58) U101.G13 ; v5(39.61,49.11) 39.57,49.11 U101.P10 ; U101.G11 v6(33.24,49.98) U101.G12 ; v1(115.71,65.04) U403.4 ; U702.4 51.28,14.69 v1(51.09,14.5) ; v5(34.04,41.98) U101.G2 33.24,41.98 v5(33.21,41.98) ; v5(34.04,41.98) U101.H2 v5(34.84,41.98) U101.J2 v5(35.64,41.98) ; v5(34.04,41.98) U101.G1 v5(33.24,41.18) ; U101.F3 v6(32.44,42.78) ; U101.F4 v6(32.44,43.58) ; U101.H3 v6(34.04,42.78) ; v5(38.04,48.38) U101.M9 ; v5(34.84,48.38) U101.H9 ; v5(33.24,44.38) U101.G5 ; v1(75.43,56.81) 75.23,57.01 R518.2 ; v5(37.24,49.18) U101.L10 ; C315.2 36.72,38.49 ; v5(34.84,49.18) U101.H10 ; U101.M2 v6(38.04,41.98) ; U101.D8 v5(30.84,47.58) ; v5(38.84,41.98) U101.N2 ; C419.1 53.73,18.84 53.35,19.22 52.84,19.22 52.59,19.48 52.33,19.48 ; C307.2 33.07,55.06 v1(33.26,55.25) ; U101.N14 v6(38.84,52.38) ; v5(36.44,41.98) U101.K2 v5(35.64,41.98) ; v5(36.44,41.98) U101.K1 ; v5(36.44,41.98) U101.L1 ; v5(36.44,41.98) U101.L2 ; U101.F5 v6(32.44,44.38) ; U101.K1 v5(36.44,41.18) ; U101.K1 v5(35.64,41.98) ; U101.L14 U101.K14 ; U101.K14 v5(35.64,51.58) ; U101.K14 v5(36.44,52.38) ; v5(30.84,42.78) U101.D3 ; v5(28.44,47.58) U101.A8 ; v5(29.24,49.18) U101.B10 v6(29.24,48.38) U101.B9 ; v5(29.24,49.18) U101.A11 v8(28.23,49.52) ; v5(29.24,49.18) U101.B11 v5(29.24,49.98) U101.B12 v5(29.24,50.78) U101.B13 v5(29.24,51.58) U101.A14 v5(28.44,52.38) ; U101.H8 34.84,47.58 v5(34.84,47.62) ; U101.G10 v6(33.24,48.38) U101.F9 ; v5(39.64,41.98) U101.P2 ; v5(35.64,51.58) U101.K13 v5(36.44,51.58) U101.L13 ; U101.E10 v6(31.64,49.18) ; U101.C5 v6(30.04,44.38) ; U101.D6 v6(30.84,45.18) ; U101.F6 v6(32.44,45.18) ; U101.H5 v6(34.04,44.38) ; U101.E9 v6(31.64,48.38) ; U101.L7 v6(37.24,45.98) ; v5(29.24,43.58) U101.B4 v5(29.24,44.38) U101.B5 v6(29.24,45.18) U101.B6 ; v5(29.24,43.58) U101.B3 v5(29.24,42.78) U101.B2 v5(29.24,41.98) U101.A1 v5(28.44,41.18) ; C316.2 32.89,38.49 ; U101.P3 39.64,42.78 v5(39.64,42.72) ; 90.65,48.68 90.69,48.64 R514.2 ; U101.D9 v5(30.84,48.38) U101.C10 ; U101.H4 v5(34.04,43.58) U101.G3 ; U101.F7 v5(33.24,45.98) ; v1(125.1,33.19) 125.08,33.14 125.1,33.07 125.01,32.87 C803.1 ; U101.F10 v6(32.44,48.38) ; U101.C9 v6(30.04,48.38) ; v1(36.49,55.25) 36.68,55.06 C308.2 ; v5(31.64,45.18) U101.E6 ; R701.1 v1(124.94,15.52) ; U101.E2 v6(31.64,41.98) ; v5(34.84,46.78) U101.H7 ; U101.P1 v6(39.64,41.18) ; U101.A7 v5(28.44,45.98) ; v6(31.64,42.78) U101.E3 ; U101.H6 v6(34.04,45.18) ; U101.F8 v5(33.24,46.78) ; U404.3 121.53,35.11 v1(121.08,35.56) ; U101.D2 v5(30.84,41.98) ; v5(31.64,45.98) U101.D7 ; U101.N7 v6(38.84,45.98)
  TOP w0.305: R613.1 v1(45.86,30.4) ; P502.1 96.53,51.67 R516.2 ; R607.1 v1(55.9,27.61) ; R823.1 116.01,29.24 v1(116.14,29.36) 116.14,29.45 116.69,30 U801.4 ; R505.1 v8(28.26,54.54) ; R611.1 v1(48.91,30.4) ; R603.2 v1(55.9,21.51) ; R517.2 v1(96.26,57.64) ; v1(122.97,60.17) 122.74,60.4 U405.7 ; R515.2 v1(93.52,57.64) ; R821.1 115.82,31.01 v1(115.86,30.98) ; 75.21,59.53 74.75,59.99 R506.2 ; R605.1 v1(55.9,24.56) ; 77.75,59.53 77.29,59.99 R509.2 ; R508.2 77.16,67.36 77.47,67.66 ; R609.1 v1(51.96,30.4) ; C651.2 v1(41.93,22.66) ; v1(121.93,31.8) 122.03,31.8 122.53,31.3 U801.7 ; 75.4,67.66 75.09,67.36 R507.2 ; C328.2 34.42,31 ; R801.1 133.72,71.7 v2(134.02,72.01) ; U601.6 v1(47.51,24.31) U601.PAD 48.02,22.79 U601.9
  TOP w0.381: T201.5 18.58,44.09 v1(18.4,44.26)
  TOP w0.394: C200.2 14.14,53.86 ; C323.2 34.76,62.56 v1(34.9,62.69) ; C211.2 16.01,39.71 ; 36.72,38.49 v1(36.41,38.3) ; v1(37.22,35.53) 37.22,34.97 ; 16.78,39.72 v1(16.6,39.54) ; v1(91.05,18.05) 90.65,18.44 R728.1 ; C324.2 34.8,65.53 34.81,65.52 ; R720.1 v1(86.63,16.6) ; P504.3 v1(44.74,72.38) ; v1(82.94,28.84) 82.38,28.28 82.38,28.07 R719.1 ; v1(33.16,34.21) 33.17,34.2 T306.5 T310.5 ; 14.14,37.9 C208.2 ; R819.1 116.24,33.43 v1(116.47,33.19) ; C733.1 v1(59.45,13.6) ; R714.2 86.08,34.94 86.73,35.59 ; R504.2 132.75,22.48 v2(132.75,22.48) ; C202.2 v1(16.01,52.05) ; P504.19 54.9,72.89 54.62,72.61 R525.1 v1(54.62,71.29) ; 32.46,58.58 v1(32.46,58.02) ; D402.C v1(66.28,80.12) ; C414.1 v1(74.89,77.78) ; T309.5 T305.5 36.51,59.36 v1(36.52,59.34) ; P504.15 v1(52.36,72.38) ; R212.2 v1(19.21,38.88) ; 93.76,35.59 94.51,34.84 R724.1 ; T200.5 v8(18.58,53.56) ; P504.9 v1(48.55,72.38) ; P504.5 v1(46.01,72.38) ; 32.89,38.49 v1(33.19,38.3) ; C428.1 92.55,69.79 ; D401.C v1(66.28,77.96) ; R203.2 v8(19.21,48.33) ; R718.1 79.67,22.95 v1(79.6,22.87) ; v1(89.22,33.74) C703.1
  TOP w0.508: 68.02,64.94 P503.1 ; P503.1 70.18,64.94 ; P503.1 69.1,63.86 ; P503.1 69.1,66.02 ; 45.92,17.83 47,17.83 47,18.91 ; 66.56,63.86 P503.3 ; P503.3 65.48,64.94 ; P503.3 66.56,66.02 ; P503.3 67.64,64.94 ; 65.06,23.67 P704.2 ; P704.2 66.14,24.75 ; P704.2 65.06,25.83 ; P704.2 63.98,24.75 ; J401.4 113.07,59.3 ; J401.4 111.8,58.03 ; J401.4 114.34,58.03 ; J401.4 113.07,56.76 ; 51.32,61.32 P503.16 ; P503.16 52.4,62.4 ; P503.16 51.32,63.48 ; P503.16 50.24,62.4 ; 83.83,61.32 P501.2 ; P501.2 82.75,62.4 ; P501.2 83.83,63.48 ; P501.2 84.91,62.4 ; P703.2 65.06,31.78 ; P703.2 65.06,29.62 ; P703.2 66.14,30.7 ; P703.2 63.98,30.7 ; 100.88,33.1 P705.2 ; P705.2 101.96,34.18 ; P705.2 100.88,35.26 ; P705.2 99.8,34.18 ; P502.1 97.48,51.55 ; P502.1 95.32,51.55 ; P502.1 96.4,50.47 ; 111.8,63.11 J401.3 ; J401.3 113.07,64.38 ; J401.3 113.07,61.84 ; J401.3 114.34,63.11 ; 53.86,61.32 P503.14 ; P503.14 54.94,62.4 ; P503.14 53.86,63.48 ; P503.14 52.78,62.4 ; 99.8,16.24 P706.2 ; P706.2 101.96,16.24 ; P706.2 100.88,17.32 ; P706.2 100.88,15.16 ; 107.99,56.76 J401.5 ; J401.5 106.72,58.03 ; J401.5 109.26,58.03 ; J401.5 107.99,59.3 ; J401.2 109.26,63.11 ; J401.2 107.99,61.84 ; J401.2 107.99,64.38 ; J401.2 106.72,63.11 ; 82.75,64.94 P501.1 ; P501.1 83.83,63.86 ; P501.1 84.91,64.94 ; P501.1 83.83,66.02 ; v1(37.09,59.34) v1(36.52,59.34) ; v1(32.58,34.21) v1(33.16,34.21)
  TOP w0.762: C732.2 v1(131.45,14.4)
  TOP w1.27: P704.2 65.38,25.07 C638.2
  L2_GND w0.508: 113.07,61.84 J401.3 ; J401.3 114.34,63.11 ; J401.3 111.8,63.11 ; J401.3 113.07,64.38 ; 47,17.83 47,18.91 ; 47,17.83 48.08,17.83 ; 47,17.83 47,16.75 ; 47,17.83 45.92,17.83 ; P701.2 116.2,23.61 ; P701.2 117.53,22.27 ; P701.2 114.86,22.27 ; P701.2 116.2,20.94 ; P503.14 54.94,62.4 ; P503.14 53.86,63.48 ; P503.14 53.86,61.32 ; P503.14 52.78,62.4 ; P705.2 100.88,35.26 ; P705.2 101.96,34.18 ; P705.2 100.88,33.1 ; P705.2 99.8,34.18 ; 106.72,58.03 J401.5 ; J401.5 107.99,59.3 ; J401.5 109.26,58.03 ; J401.5 107.99,56.76 ; P502.1 96.4,52.63 ; P502.1 95.32,51.55 ; P502.1 97.48,51.55 ; P502.1 96.4,50.47 ; 65.06,23.67 P704.2 ; P704.2 63.98,24.75 ; P704.2 66.14,24.75 ; P704.2 65.06,25.83 ; 83.83,63.86 P501.1 ; P501.1 83.83,66.02 ; P501.1 84.91,64.94 ; P501.1 82.75,64.94 ; P706.2 101.96,16.24 ; P706.2 100.88,15.16 ; P706.2 99.8,16.24 ; P706.2 100.88,17.32 ; J401.4 113.07,59.3 ; J401.4 111.8,58.03 ; J401.4 114.34,58.03 ; J401.4 113.07,56.76 ; P503.3 67.64,64.94 ; P503.3 66.56,63.86 ; P503.3 65.48,64.94 ; P503.3 66.56,66.02 ; J401.2 109.26,63.11 ; J401.2 107.99,64.38 ; J401.2 106.72,63.11 ; J401.2 107.99,61.84 ; 65.06,29.62 P703.2 ; P703.2 63.98,30.7 ; P703.2 66.14,30.7 ; P703.2 65.06,31.78 ; P503.1 70.18,64.94 ; P503.1 69.1,63.86 ; P503.1 69.1,66.02 ; P503.1 68.02,64.94 ; P501.2 83.83,63.48 ; P501.2 83.83,61.32 ; P501.2 84.91,62.4 ; P501.2 82.75,62.4 ; P503.16 51.32,63.48 ; P503.16 50.24,62.4 ; P503.16 52.4,62.4 ; P503.16 51.32,61.32
  L3_PWR w0.508: P503.3 67.64,64.94 ; P503.3 66.56,66.02 ; P503.3 65.48,64.94 ; P503.3 66.56,63.86 ; P701.2 117.53,22.27 ; P701.2 116.2,20.94 ; P701.2 116.2,23.61 ; P701.2 114.86,22.27 ; 68.02,64.94 P503.1 ; P503.1 69.1,63.86 ; P503.1 69.1,66.02 ; P503.1 70.18,64.94 ; P503.16 51.32,63.48 ; P503.16 51.32,61.32 ; P503.16 52.4,62.4 ; P503.16 50.24,62.4 ; J401.3 114.34,63.11 ; J401.3 113.07,61.84 ; J401.3 111.8,63.11 ; J401.5 109.26,58.03 ; J401.5 107.99,59.3 ; J401.5 107.99,56.76 ; J401.5 106.72,58.03 ; P501.2 84.91,62.4 ; P501.2 82.75,62.4 ; P501.2 83.83,61.32 ; P501.2 83.83,63.48 ; 96.4,52.63 P502.1 97.48,51.55 ; 65.06,23.67 P704.2 ; P704.2 63.98,24.75 ; P704.2 66.14,24.75 ; P704.2 65.06,25.83 ; 52.78,62.4 P503.14 ; P503.14 54.94,62.4 ; P503.14 53.86,61.32 ; P503.14 53.86,63.48 ; 113.07,56.76 J401.4 ; J401.4 114.34,58.03 ; J401.4 113.07,59.3 ; J401.4 111.8,58.03 ; P501.1 83.83,66.02 ; P501.1 82.75,64.94 ; P501.1 84.91,64.94 ; P501.1 83.83,63.86 ; 63.98,30.7 P703.2 ; P703.2 65.06,29.62 ; P703.2 65.06,31.78 ; P703.2 66.14,30.7 ; 109.26,63.11 J401.2 107.99,61.84
  L4_GND w0.508: 82.75,62.4 P501.2 ; P501.2 83.83,63.48 ; P501.2 84.91,62.4 ; P501.2 83.83,61.32 ; 47,17.83 48.08,17.83 ; 47,17.83 45.92,17.83 ; 47,17.83 47,16.75 ; 47,17.83 47,18.91 ; P704.2 66.14,24.75 ; P704.2 63.98,24.75 ; P704.2 65.06,25.83 ; P704.2 65.06,23.67 ; 52.78,62.4 P503.14 ; P503.14 53.86,63.48 ; P503.14 54.94,62.4 ; P503.14 53.86,61.32 ; P706.2 101.96,16.24 ; P706.2 100.88,17.32 ; P706.2 100.88,15.16 ; P706.2 99.8,16.24 ; P503.3 67.64,64.94 ; P503.3 66.56,66.02 ; P503.3 66.56,63.86 ; P503.3 65.48,64.94 ; P503.16 52.4,62.4 ; P503.16 51.32,63.48 ; P503.16 50.24,62.4 ; P503.16 51.32,61.32 ; J401.2 109.26,63.11 ; J401.2 107.99,61.84 ; J401.2 107.99,64.38 ; J401.2 106.72,63.11 ; 96.4,50.47 P502.1 ; P502.1 97.48,51.55 ; P502.1 95.32,51.55 ; P502.1 96.4,52.63 ; P705.2 101.96,34.18 ; P705.2 99.8,34.18 ; P705.2 100.88,33.1 ; P705.2 100.88,35.26 ; 63.98,30.7 P703.2 ; P703.2 65.06,29.62 ; P703.2 66.14,30.7 ; P703.2 65.06,31.78 ; P701.2 117.53,22.27 ; P701.2 116.2,23.61 ; P701.2 114.86,22.27 ; P701.2 116.2,20.94 ; 111.8,58.03 J401.4 ; J401.4 113.07,56.76 ; J401.4 113.07,59.3 ; J401.4 114.34,58.03 ; J401.3 114.34,63.11 ; J401.3 113.07,61.84 ; J401.3 111.8,63.11 ; J401.3 113.07,64.38 ; P501.1 84.91,64.94 ; P501.1 82.75,64.94 ; P501.1 83.83,63.86 ; P501.1 83.83,66.02 ; 69.1,63.86 P503.1 ; P503.1 68.02,64.94 ; P503.1 70.18,64.94 ; P503.1 69.1,66.02 ; J401.5 109.26,58.03 ; J401.5 107.99,56.76 ; J401.5 107.99,59.3 ; J401.5 106.72,58.03
  L5_SIG w0.508: 100.88,33.1 P705.2 ; P705.2 101.96,34.18 ; P705.2 100.88,35.26 ; P705.2 99.8,34.18 ; 65.06,23.67 P704.2 ; P704.2 65.06,25.83 ; P704.2 66.14,24.75 ; P704.2 63.98,24.75 ; 65.06,31.78 P703.2 66.14,30.7 ; 53.86,61.32 P503.14 ; P503.14 52.78,62.4 ; P503.14 54.94,62.4 ; P701.2 117.53,22.27 ; P701.2 116.2,23.61 ; P701.2 114.86,22.27 ; P701.2 116.2,20.94 ; P706.2 101.96,16.24 ; P706.2 100.88,15.16 ; P706.2 100.88,17.32 ; P706.2 99.8,16.24 ; P503.3 67.64,64.94 ; P503.3 65.48,64.94 ; P503.3 66.56,66.02 ; 107.99,56.76 J401.5 ; J401.5 107.99,59.3 ; J401.5 106.72,58.03 ; J401.5 109.26,58.03 ; 47,17.83 47,18.91 ; 47,17.83 45.92,17.83 ; 47,17.83 48.08,17.83 ; 47,17.83 47,16.75 ; 95.32,51.55 P502.1 97.48,51.55 ; 50.24,62.4 P503.16 ; P503.16 52.4,62.4 ; P503.16 51.32,61.32 ; 83.83,63.86 P501.1 ; P501.1 83.83,66.02 ; P501.1 84.91,64.94 ; P501.2 84.91,62.4 ; P501.2 83.83,61.32 ; P501.2 82.75,62.4 ; P501.2 83.83,63.48 ; J401.2 109.26,63.11 ; J401.2 106.72,63.11 ; J401.2 107.99,61.84 ; 113.07,56.76 J401.4 ; J401.4 111.8,58.03 ; J401.4 113.07,59.3 ; J401.4 114.34,58.03 ; 68.02,64.94 P503.1 ; P503.1 69.1,63.86 ; P503.1 69.1,66.02 ; 113.07,61.84 J401.3 ; J401.3 111.8,63.11 ; J401.3 114.34,63.11
  L6_GND w0.508: 68.02,64.94 P503.1 ; P503.1 70.18,64.94 ; P503.1 69.1,63.86 ; P503.1 69.1,66.02 ; P701.2 117.53,22.27 ; P701.2 116.2,20.94 ; P701.2 116.2,23.61 ; P701.2 114.86,22.27 ; P705.2 100.88,35.26 ; P705.2 101.96,34.18 ; P705.2 99.8,34.18 ; P705.2 100.88,33.1 ; 99.8,16.24 P706.2 ; P706.2 101.96,16.24 ; P706.2 100.88,15.16 ; P706.2 100.88,17.32 ; 82.75,62.4 P501.2 ; P501.2 84.91,62.4 ; P501.2 83.83,63.48 ; P501.2 83.83,61.32 ; 52.78,62.4 P503.14 ; P503.14 54.94,62.4 ; P503.14 53.86,61.32 ; P503.14 53.86,63.48 ; 111.8,58.03 J401.4 ; J401.4 114.34,58.03 ; J401.4 113.07,59.3 ; J401.4 113.07,56.76 ; 96.4,50.47 P502.1 ; P502.1 95.32,51.55 ; P502.1 97.48,51.55 ; P502.1 96.4,52.63 ; P503.3 67.64,64.94 ; P503.3 66.56,63.86 ; P503.3 66.56,66.02 ; P503.3 65.48,64.94 ; J401.3 113.07,64.38 ; J401.3 114.34,63.11 ; J401.3 113.07,61.84 ; J401.3 111.8,63.11 ; 63.98,30.7 P703.2 ; P703.2 66.14,30.7 ; P703.2 65.06,29.62 ; P703.2 65.06,31.78 ; P503.16 51.32,63.48 ; P503.16 50.24,62.4 ; P503.16 51.32,61.32 ; P503.16 52.4,62.4 ; 47,16.75 47,17.83 ; 47,17.83 45.92,17.83 ; 47,17.83 47,18.91 ; 47,17.83 48.08,17.83 ; 106.72,63.11 J401.2 ; J401.2 107.99,61.84 ; J401.2 107.99,64.38 ; J401.2 109.26,63.11 ; 82.75,64.94 P501.1 ; P501.1 83.83,66.02 ; P501.1 84.91,64.94 ; P501.1 83.83,63.86 ; P704.2 65.06,25.83 ; P704.2 65.06,23.67 ; P704.2 63.98,24.75 ; P704.2 66.14,24.75 ; 106.72,58.03 J401.5 ; J401.5 107.99,56.76 ; J401.5 109.26,58.03 ; J401.5 107.99,59.3
  L7_SIG w0.152: v5(34.84,49.18) 34.84,49.42 34.3,49.96
  L7_SIG w0.508: 106.72,58.03 J401.5 ; J401.5 109.26,58.03 ; J401.5 107.99,59.3 ; P503.16 51.32,63.48 ; P503.16 51.32,61.32 ; P503.16 52.4,62.4 ; P503.16 50.24,62.4 ; P503.14 54.94,62.4 ; P503.14 52.78,62.4 ; P503.14 53.86,63.48 ; P503.14 53.86,61.32 ; 100.88,33.1 P705.2 ; P705.2 99.8,34.18 ; P705.2 100.88,35.26 ; P705.2 101.96,34.18 ; 113.07,61.84 J401.3 ; J401.3 114.34,63.11 ; J401.3 111.8,63.11 ; J401.3 113.07,64.38 ; P501.2 84.91,62.4 ; P501.2 83.83,61.32 ; P501.2 83.83,63.48 ; P501.2 82.75,62.4 ; 111.8,58.03 J401.4 ; J401.4 114.34,58.03 ; J401.4 113.07,59.3 ; P706.2 101.96,16.24 ; P706.2 100.88,17.32 ; P706.2 100.88,15.16 ; P706.2 99.8,16.24 ; 66.56,63.86 P503.3 ; P503.3 65.48,64.94 ; P503.3 66.56,66.02 ; P503.3 67.64,64.94 ; J401.2 107.99,64.38 ; J401.2 107.99,61.84 ; J401.2 106.72,63.11 ; J401.2 109.26,63.11 ; 82.75,64.94 P501.1 ; P501.1 83.83,63.86 ; P501.1 83.83,66.02 ; P501.1 84.91,64.94 ; 69.1,63.86 P503.1 ; P503.1 70.18,64.94 ; P503.1 68.02,64.94 ; P503.1 69.1,66.02 ; 96.4,50.47 P502.1 ; P502.1 96.4,52.63 ; P502.1 97.48,51.55 ; P502.1 95.32,51.55 ; P703.2 66.14,30.7 ; P703.2 63.98,30.7 ; P703.2 65.06,29.62 ; P703.2 65.06,31.78 ; 47,17.83 47,18.91 ; 47,17.83 45.92,17.83 ; 47,17.83 47,16.75 ; 47,17.83 48.08,17.83 ; 116.2,20.94 P701.2 ; P701.2 117.53,22.27 ; P701.2 116.2,23.61 ; P701.2 114.86,22.27 ; P704.2 65.06,25.83 ; P704.2 63.98,24.75 ; P704.2 65.06,23.67 ; P704.2 66.14,24.75
  L8_SIG w0.152: 33.82,47.13 33.63,46.94 33.63,46.75 33.54,46.66
  L8_SIG w0.508: 65.48,64.94 P503.3 66.56,63.86 ; 106.72,63.11 J401.2 ; J401.2 109.26,63.11 ; J401.2 107.99,64.38 ; J401.2 107.99,61.84 ; 84.91,62.4 P501.2 82.75,62.4 ; 51.32,61.32 P503.16 ; P503.16 51.32,63.48 ; P503.16 50.24,62.4 ; 111.8,63.11 J401.3 ; J401.3 113.07,61.84 ; J401.3 114.34,63.11 ; J401.3 113.07,64.38 ; P705.2 100.88,35.26 ; P705.2 101.96,34.18 ; P705.2 99.8,34.18 ; 95.32,51.55 P502.1 ; P502.1 96.4,50.47 ; P502.1 97.48,51.55 ; 47,16.75 47,17.83 ; 47,17.83 47,18.91 ; 47,17.83 48.08,17.83 ; 47,17.83 45.92,17.83 ; P706.2 100.88,17.32 ; P706.2 99.8,16.24 ; P706.2 101.96,16.24 ; 63.98,24.75 P704.2 ; P704.2 65.06,25.83 ; P704.2 66.14,24.75 ; 117.53,22.27 P701.2 116.2,20.94 ; J401.5 107.99,59.3 ; J401.5 107.99,56.76 ; J401.5 109.26,58.03 ; J401.5 106.72,58.03 ; P503.14 53.86,63.48 ; P503.14 53.86,61.32 ; P503.14 54.94,62.4 ; P703.2 66.14,30.7 ; P703.2 65.06,31.78 ; P703.2 63.98,30.7 ; J401.4 113.07,59.3 ; J401.4 114.34,58.03 ; J401.4 111.8,58.03 ; J401.4 113.07,56.76 ; P503.1 70.18,64.94 ; P503.1 69.1,66.02 ; P503.1 69.1,63.86 ; 84.91,64.94 P501.1 82.75,64.94
  L9_GND w0.508: 116.2,20.94 P701.2 ; P701.2 114.86,22.27 ; P701.2 116.2,23.61 ; P701.2 117.53,22.27 ; P705.2 101.96,34.18 ; P705.2 100.88,35.26 ; P705.2 99.8,34.18 ; P705.2 100.88,33.1 ; J401.4 113.07,59.3 ; J401.4 113.07,56.76 ; J401.4 114.34,58.03 ; J401.4 111.8,58.03 ; 100.88,15.16 P706.2 ; P706.2 99.8,16.24 ; P706.2 101.96,16.24 ; P706.2 100.88,17.32 ; 47,16.75 47,17.83 ; 47,17.83 48.08,17.83 ; 47,17.83 45.92,17.83 ; 47,17.83 47,18.91 ; P704.2 66.14,24.75 ; P704.2 65.06,25.83 ; P704.2 65.06,23.67 ; P704.2 63.98,24.75 ; 107.99,61.84 J401.2 ; J401.2 109.26,63.11 ; J401.2 107.99,64.38 ; J401.2 106.72,63.11 ; 107.99,56.76 J401.5 ; J401.5 109.26,58.03 ; J401.5 106.72,58.03 ; J401.5 107.99,59.3 ; 69.1,63.86 P503.1 ; P503.1 69.1,66.02 ; P503.1 68.02,64.94 ; P503.1 70.18,64.94 ; P501.1 84.91,64.94 ; P501.1 83.83,63.86 ; P501.1 82.75,64.94 ; P501.1 83.83,66.02 ; P503.14 54.94,62.4 ; P503.14 53.86,61.32 ; P503.14 52.78,62.4 ; P503.14 53.86,63.48 ; P703.2 66.14,30.7 ; P703.2 65.06,29.62 ; P703.2 65.06,31.78 ; P703.2 63.98,30.7 ; 82.75,62.4 P501.2 ; P501.2 84.91,62.4 ; P501.2 83.83,63.48 ; P501.2 83.83,61.32 ; P502.1 96.4,52.63 ; P502.1 96.4,50.47 ; P502.1 95.32,51.55 ; P502.1 97.48,51.55 ; 50.24,62.4 P503.16 ; P503.16 51.32,63.48 ; P503.16 51.32,61.32 ; P503.16 52.4,62.4 ; J401.3 113.07,64.38 ; J401.3 114.34,63.11 ; J401.3 113.07,61.84 ; J401.3 111.8,63.11 ; 66.56,63.86 P503.3 ; P503.3 67.64,64.94 ; P503.3 66.56,66.02 ; P503.3 65.48,64.94
  L10_SIG w0.127: 29.09,48.05 29.23,47.92 29.38,47.92 29.73,47.57 29.73,47.42
  L10_SIG w0.508: 116.2,20.94 P701.2 ; P701.2 114.86,22.27 ; P701.2 116.2,23.61 ; P701.2 117.53,22.27 ; 47,16.75 47,17.83 ; 47,17.83 48.08,17.83 ; 47,17.83 45.92,17.83 ; 47,17.83 47,18.91 ; J401.3 114.34,63.11 ; J401.3 113.07,64.38 ; J401.3 113.07,61.84 ; J401.3 111.8,63.11 ; 65.06,29.62 P703.2 ; P703.2 66.14,30.7 ; P703.2 63.98,30.7 ; P703.2 65.06,31.78 ; 111.8,58.03 J401.4 ; J401.4 114.34,58.03 ; J401.4 113.07,59.3 ; J401.4 113.07,56.76 ; P502.1 97.48,51.55 ; P502.1 95.32,51.55 ; P502.1 96.4,50.47 ; P502.1 96.4,52.63 ; 68.02,64.94 P503.1 ; P503.1 69.1,66.02 ; P503.1 69.1,63.86 ; P503.1 70.18,64.94 ; 83.83,61.32 P501.2 ; P501.2 84.91,62.4 ; P501.2 83.83,63.48 ; P501.2 82.75,62.4 ; 53.86,61.32 P503.14 ; P503.14 52.78,62.4 ; P503.14 53.86,63.48 ; J401.2 107.99,64.38 ; J401.2 106.72,63.11 ; J401.2 109.26,63.11 ; J401.2 107.99,61.84 ; J401.5 109.26,58.03 ; J401.5 107.99,59.3 ; J401.5 106.72,58.03 ; J401.5 107.99,56.76 ; P503.3 66.56,66.02 ; P503.3 65.48,64.94 ; P503.3 67.64,64.94 ; P503.3 66.56,63.86 ; 99.8,16.24 P706.2 ; P706.2 101.96,16.24 ; P706.2 100.88,15.16 ; P706.2 100.88,17.32 ; 52.4,62.4 P503.16 51.32,63.48 ; 99.8,34.18 P705.2 100.88,35.26 ; 82.75,64.94 P501.1 83.83,63.86
  L11_GND w0.508: P701.2 116.2,23.61 ; P701.2 116.2,20.94 ; P701.2 114.86,22.27 ; P701.2 117.53,22.27 ; 47,16.75 47,17.83 ; 47,17.83 45.92,17.83 ; 47,17.83 48.08,17.83 ; 47,17.83 47,18.91 ; 100.88,33.1 P705.2 ; P705.2 100.88,35.26 ; P705.2 101.96,34.18 ; P705.2 99.8,34.18 ; P503.3 67.64,64.94 ; P503.3 65.48,64.94 ; P503.3 66.56,66.02 ; P503.3 66.56,63.86 ; P503.1 70.18,64.94 ; P503.1 69.1,63.86 ; P503.1 68.02,64.94 ; P503.1 69.1,66.02 ; 50.24,62.4 P503.16 ; P503.16 51.32,63.48 ; P503.16 51.32,61.32 ; P503.16 52.4,62.4 ; J401.2 109.26,63.11 ; J401.2 107.99,64.38 ; J401.2 107.99,61.84 ; J401.2 106.72,63.11 ; P706.2 100.88,17.32 ; P706.2 99.8,16.24 ; P706.2 100.88,15.16 ; P706.2 101.96,16.24 ; P703.2 66.14,30.7 ; P703.2 65.06,31.78 ; P703.2 63.98,30.7 ; P703.2 65.06,29.62 ; P704.2 65.06,25.83 ; P704.2 66.14,24.75 ; P704.2 65.06,23.67 ; P704.2 63.98,24.75 ; P501.1 83.83,66.02 ; P501.1 84.91,64.94 ; P501.1 82.75,64.94 ; P501.1 83.83,63.86 ; P502.1 97.48,51.55 ; P502.1 96.4,50.47 ; P502.1 95.32,51.55 ; P502.1 96.4,52.63 ; J401.4 113.07,59.3 ; J401.4 113.07,56.76 ; J401.4 114.34,58.03 ; J401.4 111.8,58.03 ; 52.78,62.4 P503.14 ; P503.14 53.86,61.32 ; P503.14 54.94,62.4 ; P503.14 53.86,63.48 ; 83.83,61.32 P501.2 ; P501.2 84.91,62.4 ; P501.2 83.83,63.48 ; P501.2 82.75,62.4 ; J401.3 114.34,63.11 ; J401.3 113.07,61.84 ; J401.3 111.8,63.11 ; J401.3 113.07,64.38 ; J401.5 107.99,59.3 ; J401.5 107.99,56.76 ; J401.5 106.72,58.03 ; J401.5 109.26,58.03
  L12_PWR w0.508: 113.07,61.84 J401.3 ; J401.3 111.8,63.11 ; J401.3 113.07,64.38 ; J401.3 114.34,63.11 ; 50.24,62.4 P503.16 ; P503.16 51.32,63.48 ; P503.16 52.4,62.4 ; P503.16 51.32,61.32 ; P503.14 54.94,62.4 ; P503.14 52.78,62.4 ; P503.14 53.86,61.32 ; P503.14 53.86,63.48 ; P503.3 67.64,64.94 ; P503.3 66.56,63.86 ; P503.3 65.48,64.94 ; P503.3 66.56,66.02 ; 106.72,58.03 J401.5 ; J401.5 109.26,58.03 ; J401.5 107.99,59.3 ; J401.5 107.99,56.76 ; 107.99,61.84 J401.2 ; J401.2 109.26,63.11 ; J401.2 107.99,64.38 ; J401.2 106.72,63.11 ; P706.2 100.88,17.32 ; P706.2 100.88,15.16 ; P706.2 99.8,16.24 ; P706.2 101.96,16.24 ; 66.14,30.7 P703.2 65.06,31.78 ; 100.88,33.1 P705.2 ; P705.2 100.88,35.26 ; P705.2 101.96,34.18 ; P705.2 99.8,34.18 ; 68.02,64.94 P503.1 ; P503.1 69.1,66.02 ; P503.1 69.1,63.86 ; P503.1 70.18,64.94 ; J401.4 114.34,58.03 ; J401.4 113.07,59.3 ; J401.4 111.8,58.03 ; J401.4 113.07,56.76 ; P501.2 83.83,63.48 ; P501.2 84.91,62.4 ; P501.2 82.75,62.4 ; P501.2 83.83,61.32 ; P501.1 83.83,66.02 ; P501.1 84.91,64.94 ; P501.1 83.83,63.86 ; P501.1 82.75,64.94 ; 63.98,24.75 P704.2 65.52,25.81
  L13_GND w0.508: P705.2 101.96,34.18 ; P705.2 100.88,35.26 ; P705.2 99.8,34.18 ; P705.2 100.88,33.1 ; 100.88,15.16 P706.2 ; P706.2 99.8,16.24 ; P706.2 101.96,16.24 ; P706.2 100.88,17.32 ; 113.07,56.76 J401.4 ; J401.4 111.8,58.03 ; J401.4 114.34,58.03 ; J401.4 113.07,59.3 ; 106.72,58.03 J401.5 ; J401.5 107.99,56.76 ; J401.5 109.26,58.03 ; J401.5 107.99,59.3 ; P501.1 84.91,64.94 ; P501.1 82.75,64.94 ; P501.1 83.83,66.02 ; P501.1 83.83,63.86 ; 68.02,64.94 P503.1 ; P503.1 69.1,63.86 ; P503.1 70.18,64.94 ; P503.1 69.1,66.02 ; P503.14 53.86,63.48 ; P503.14 53.86,61.32 ; P503.14 52.78,62.4 ; P503.14 54.94,62.4 ; 47,17.83 48.08,17.83 ; 47,17.83 45.92,17.83 ; 47,17.83 47,16.75 ; 47,17.83 47,18.91 ; 65.06,23.67 P704.2 ; P704.2 66.14,24.75 ; P704.2 65.06,25.83 ; P704.2 63.98,24.75 ; 106.72,63.11 J401.2 ; J401.2 107.99,61.84 ; J401.2 107.99,64.38 ; J401.2 109.26,63.11 ; P503.3 66.56,66.02 ; P503.3 67.64,64.94 ; P503.3 65.48,64.94 ; P503.3 66.56,63.86 ; P701.2 117.53,22.27 ; P701.2 116.2,23.61 ; P701.2 114.86,22.27 ; P701.2 116.2,20.94 ; 96.4,50.47 P502.1 ; P502.1 97.48,51.55 ; P502.1 95.32,51.55 ; P502.1 96.4,52.63 ; J401.3 114.34,63.11 ; J401.3 113.07,61.84 ; J401.3 113.07,64.38 ; J401.3 111.8,63.11 ; P703.2 65.06,31.78 ; P703.2 66.14,30.7 ; P703.2 63.98,30.7 ; P703.2 65.06,29.62 ; P503.16 51.32,63.48 ; P503.16 51.32,61.32 ; P503.16 52.4,62.4 ; P503.16 50.24,62.4 ; 83.83,61.32 P501.2 ; P501.2 84.91,62.4 ; P501.2 82.75,62.4 ; P501.2 83.83,63.48
  BOTTOM w0.127: 23.95,20.11 L217.1 C217.2
  BOTTOM w0.203: C330.2 v4(16.69,46.06) ; 27.04,63.96 v1(26.45,63.74) ; 36.63,53.26 37.05,53.68 40.14,53.68 40.85,53.65 ; 31,42.97 30.87,42.97 30.62,43.22 30.62,43.89 30.72,43.99 30.72,44.14 30.85,44.27 ; C331.2 v4(19.67,46.02) ; 26.03,66.75 v1(25.44,66.54)
  BOTTOM w0.254: C528.2 69.73,61.01 70.37,61.64 ; v1(57.18,67.43) 57.03,67.27 C525.2 ; 62.11,66.85 61.8,67.16 ; 62.11,66.85 62.11,66.88 v1(61.83,67.16) ; 62.11,66.85 C524.2 ; 60.21,61.64 59.57,61.01 C532.2 ; R419.2 98.44,78.89 ; R417.1 v1(98.3,77.04) ; v1(29.43,38.53) 29.5,38.53 29.89,38.92 C603.2 29.87,39.49 C605.2 ; v3(37.78,49.53) 37.78,49.52 C654.2 ; 65.29,61.64 64.65,61.01 C530.2 ; v1(91.9,71.09) 91.9,69.7 92.04,69.57 92.04,68.63 U401.4 ; C625.2 v3(28.94,47.82) ; v3(37.24,50.72) 37.41,50.9 C642.2 ; C606.2 32.1,43.25 v3(32.01,43.25) ; 79.94,61.5 79.38,60.95 C503.2 ; C505.2 81.99,60.93 v1(82.59,61.53) ; C649.2 49.54,22.27 v1(49.55,22.28) ; C645.2 30.3,48.37 30.62,48.05 ; U401.13 87.54,69.82 88.09,70.37 v1(88.09,71.09) ; C610.2 33.97,42.05 v5(34.04,41.98) ; 62.75,61.64 62.75,61.29 C531.2 ; U701.10 92.06,24.12 v1(92.32,23.86) 92.07,23.62 U701.11 ; 32.89,64.58 C321.2 ; C413.2 v1(86.95,64.74) ; C609.2 36.64,42.82 36.64,42.17 v5(36.44,41.98) ; U701.2 92.06,28.12 v1(92.32,27.86) 92.07,27.62 U701.3 ; v5(33.24,45.98) 33.08,45.81 C619.2 ; v1(89.36,71.09) 89.36,70.14 89.54,69.96 U401.9 ; C529.2 67.19,61.01 67.83,61.64 ; v1(82.33,25.87) v1(82.33,25.11) 82.1,24.87 Q701.4 81.42,25.31 v1(81.7,25.59) ; v5(29.24,44.38) 29.34,44.28 C629.2 ; v3(30.03,50.87) 30.22,50.68 C640.2 ; C506.2 v1(81.92,67.03) ; C615.2 v3(35.33,44.07) ; C504.2 v1(79.38,67.03) ; C644.2 v3(38.88,42.83) ; C523.2 64.65,66.88 v1(64.37,67.16) ; C526.2 54.49,66.55 v1(55.16,67.22) ; C527.2 52.42,66.37 v1(53.14,67.09) ; v1(85.46,25.87) 85.21,25.62 U701.30 ; v5(28.44,44.38) 28.46,44.39 C621.2 ; C627.2 v3(35.19,46.18)
  BOTTOM w0.305: C616.2 v3(41,42.97) ; v5(39.64,41.98) 39.63,41.96 C617.2 ; v3(38.72,47.66) 38.67,47.72 C637.2 ; v3(41.42,47.16) 41.03,47.16 C613.2 ; U402.2 v1(76.76,79.04) ; Q701.1 v1(79.6,22.87) ; C326.2 41.37,35.84 v3(41.36,35.84) ; C633.2 v4(29.85,53.51) ; 34.81,49.07 34.74,49.01 C631.2 ; v3(30.6,51.3) C641.2
  BOTTOM w0.381: 84.19,35.59 83.81,35.21 C701.2 ; R710.2 C712.1 v1(93.76,33.87) ; C620.2 v1(25.79,47.77) ; 86.73,35.59 87.45,34.87 C704.1
  BOTTOM w0.394: P801.A8 143.66,63.75 v2(144.36,64.45) ; P801.D19 v2(140.37,49.15) ; P801.F15 v2(136.56,55.5) P801.G14 ; P801.K18 P801.J17 v2(132.75,52.96) ; T202.5 v1(28.03,25.39) ; v2(144.31,48.91) 143.92,48.51 P801.A20 P801.B19 ; v2(144.39,51.63) 144.37,51.63 143.67,52.32 P801.A17 ; P801.G23 v2(136.56,44.07) ; P801.B26 v2(142.91,40.26) ; 91.81,35.59 91.09,34.87 C708.1 ; R228.2 v1(24.27,59.32) ; P801.E20 P801.F21 v2(137.83,46.61) ; P801.G29 v2(136.56,36.45) ; v2(140.37,63.12) P801.C8 ; P801.H21 v2(134.02,47.88) P801.J20 v2(132.75,49.15) ; C635.2 36.1,50.75 ; P801.K15 v2(131.48,55.5) ; v1(122.53,71.42) Y402.3 Y403.2 Y401.3 ; P801.C32 v2(141.64,32.64) ; v1(17.96,30.14) 17.9,30.14 17.9,30.18 C233.2 ; v2(137.83,40.31) 137.88,40.31 P801.E26 ; v2(137.88,35.2) 137.81,35.2 P801.F30 ; P801.J29 v2(134.02,36.45) ; P801.E38 v2(139.1,25.02) ; P801.H12 v2(134.02,59.31) P801.J11 ; R220.2 v1(23.3,27.7) ; v3(39.2,44.83) 39.2,45.55 C612.2 ; P705.2 100.54,33.84 C737.1 ; P801.A24 143.89,43.43 v2(144.54,42.79) ; P801.J5 P801.J4 v2(132.75,69.47) ; C647.2 v1(36.86,62.77) ; C406.1 v1(104.1,73.18) ; P801.K33 v2(131.48,31.37) ; C705.2 84.9,17.23 v1(84.57,16.9) ; v2(144.28,37.72) 144.19,37.72 P801.A28 ; P801.A37 v2(144.18,26.29) ; C711.1 v1(92.02,21.51) ; P801.E1 v2(139.1,73.28) ; C626.2 18.62,54.34 v1(18.62,54.34) ; P801.G38 v2(136.56,25.02) ; v2(135.28,69.42) 135.87,68.83 P801.G4 ; P801.K21 v2(132.75,46.61) ; C706.1 v1(86.63,16.6) ; P801.A21 144.25,46.55 v2(145.91,46.55) ; P801.E4 137.86,68.22 v2(137.85,68.22) ; P801.F27 v2(137.83,38.99) ; P801.B27 v2(142.91,38.99) ; P801.E35 v2(139.1,28.83) ; P801.H30 v2(134.02,35.18) ; v1(90,16.6) C710.1 ; P801.D10 v2(140.37,60.58) ; C235.2 19.59,32.61 19.63,32.62 19.63,32.59 v1(19.68,32.59) ; P801.B11 v2(142.91,59.31) ; v2(144.39,52.9) 144.37,52.9 143.67,53.59 P801.A16 ; T307.5 v4(21.59,44.96) ; v2(141.64,41.53) P801.C25 P801.C24 ; P801.B23 v2(142.91,45.34) P801.B22 ; v1(97.18,61.01) R404.2 ; P801.B15 v2(142.91,54.23) ; P801.C1 v2(141.64,72.01) P801.B2 ; v2(141.64,56.77) P801.C13 P801.C12 ; P801.K30 v2(131.48,35.18) ; P801.G32 v2(136.56,32.64) ; 98.44,78.89 99.06,78.89 v1(99.17,79) ; P801.J35 v2(134.02,28.83) ; P801.B10 v2(142.91,60.58) ; v2(142.91,51.69) P801.B18 P801.C17 ; 24.24,20.02 24.25,19.98 24.31,19.99 ; 24.24,20.02 C217.2 ; 24.24,20.02 23.95,20.11 ; P801.E32 v2(139.1,32.64) ; P801.C36 v2(141.64,27.56) ; P801.H24 v2(134.02,44.07) P801.J23 v2(132.75,45.34) ; v2(141.64,54.23) P801.C16 P801.D16 ; P801.H33 v2(135.29,31.37) ; T308.2 v1(29.1,62.67) ; v2(140.37,37.72) P801.D28 v2(139.1,38.99) ; P801.F33 v2(137.83,31.37) ; v2(134.03,69.5) 134.63,70.1 P801.H3 ; P801.A9 144.55,62.48 v2(145.22,61.81) ; v2(144.38,58) 143.7,58.67 P801.A12 ; v2(140.36,70.71) 140.35,70.71 P801.D3 P801.C4 v2(141.64,68.2) P801.C5 ; T204.5 22.7,34.57 22.7,34.16 ; P801.F39 v2(137.83,23.75) ; P801.C40 v2(141.64,22.48) ; P801.G17 v2(135.29,52.96) ; v1(91.44,67.36) C410.1 C411.1 ; P801.G35 v2(136.56,30.1) ; v2(144.38,56.73) 143.7,57.4 P801.A13 ; P801.D22 v2(140.37,46.61) P801.C21 P801.C20 ; P801.E40 v2(139.1,22.48) ; P801.F12 v2(137.83,58.04) ; P801.F3 v2(137.83,69.47) ; P801.A29 v2(144.18,36.45) ; P801.F6 v2(137.83,65.66) ; P801.K39 v2(131.48,23.75) ; P801.F36 v2(137.83,27.56) ; P801.K3 v2(131.48,70.74) P801.K2 ; P801.G26 v2(136.56,40.26) ; C636.2 36.57,45.68 36.57,45.53 36.84,45.26 v3(36.84,45.05) ; P801.E29 v2(139.1,36.45) ; C618.2 v3(44.56,42.97) ; C219.2 25.24,22.81 ; P801.J26 v2(132.75,41.53) ; C405.1 v1(109.44,77.5) ; P801.E14 v2(137.83,56.77) ; v2(136.56,51.69) P801.F18 P801.E17 ; R402.1 v1(104.68,65.55) ; v1(99.15,79.96) R418.2 ; P801.H36 v2(134.02,27.56) ; R403.1 v1(97.18,65.56) ; P801.D13 v2(139.1,58.04) ; P801.A5 v2(144.18,66.93) ; P801.J40 v2(132.75,22.48) ; P801.J14 v2(134.02,55.5) ; P801.B31 v2(142.91,33.91) ; v1(103.89,72.29) 103.9,72.29 104.04,72.15 R428.2 ; P801.K12 v2(131.48,58.04) ; P801.H39 v2(135.29,23.75) ; P801.B7 v2(142.91,65.66) P801.B6 ; T203.5 v1(19.75,56.86) ; P801.H6 v2(134.02,66.93) ; P801.G40 v2(136.56,22.48) ; P801.B30 v2(142.91,35.18) ; P801.C28 v2(141.64,37.72) ; P801.J38 v2(134.02,25.02) ; P801.B39 v2(142.91,23.75) ; P801.J32 v2(134.02,32.64) ; P801.G5 v2(136.56,66.93) ; v3(40.03,49.02) 40.03,49.91 C653.2 ; v1(122.99,72.16) R409.1 ; P801.K6 v2(131.48,66.93) ; P801.A33 v2(144.18,31.37) ; R713.2 88.63,33.16 v1(89.22,33.74) 89.7,33.26 C702.1 ; v1(13.06,61.08) 13.06,61.07 C630.2 ; R401.1 v1(105.81,63.78) ; P801.K24 132.75,44.07 v2(132.75,44.08) ; P801.D25 P801.E26 ; P801.E26 v2(137.83,41.53) ; P801.K27 v2(131.48,38.99) ; P801.A36 v2(144.18,27.56) ; P801.B38 v2(142.91,25.02) ; P801.C33 v2(141.64,31.37) ; P801.B34 v2(142.91,30.1) ; P801.E23 v2(137.83,45.34) ; v2(137.83,61.85) P801.F9 ; v2(135.29,73.28) P801.G1 ; P801.J1 v2(134.02,72.01) ; v1(127.14,73.22) C738.1 ; v2(135.29,61.85) P801.H9 P801.G8 ; P801.B35 v2(142.91,28.83) ; v2(144.51,41.7) 144.01,41.7 P801.A25 ; v2(140.37,61.85) P801.C9 v2(141.64,61.85) ; v2(139.1,60.58) P801.E11 ; P801.D37 v2(140.37,26.29) ; v2(139.1,64.39) P801.D7 ; P801.K36 v2(131.48,27.56) ; C420.2 v1(94.54,79.66) ; P801.C29 v2(141.64,36.45) ; P801.B14 v2(142.91,55.5) ; v2(142.89,69.48) 142.89,69.49 P801.B3 ; C225.2 v1(17.27,62.92) ; P801.D6 v2(139.1,66.93) P801.E5 ; P801.F24 v2(137.83,42.8) ; C404.2 v1(123.8,75.51) ; P801.A4 v2(144.18,68.2) ; T307.2 v4(21.59,48.23) ; P801.H18 v2(134.02,51.69) ; P801.G20 v2(136.56,47.88) ; P801.G11 v2(136.56,59.31) ; P801.H27 v2(134.02,40.26) ; R236.2 v1(19.09,37.86) ; P801.H15 v2(134.02,54.23) ; v1(86.6,33.69) R706.2 ; P801.D39 v2(140.37,23.75) ; P801.F2 v2(136.56,70.74) ; P801.A1 v2(144.18,72.01) ; P801.J8 v2(132.75,64.39) ; T308.5 v1(26.3,61.63) ; P801.A40 v2(144.18,22.48) ; P801.D2 v2(140.37,72.01) ; v2(139.1,63.12) P801.E8 ; P801.A32 v2(144.18,32.64) ; C227.2 19.02,60.54 ; P801.C38 v2(141.64,25.02) ; P801.K9 v2(131.52,61.88)
  BOTTOM w0.508: P503.3 67.64,64.94 ; P503.3 66.56,66.02 ; P503.3 66.56,63.86 ; P503.3 65.48,64.94 ; 68.02,64.94 P503.1 ; P503.1 70.18,64.94 ; P503.1 69.1,66.02 ; P503.1 69.1,63.86 ; v1(71.82,32.12) 71.83,32.11 R732.2 ; 83.83,61.32 P501.2 ; P501.2 83.83,63.48 ; P501.2 84.91,62.4 ; P501.2 82.75,62.4 ; v1(57.92,32.75) 57.92,31.92 57.51,31.51 C611.2 v1(55.08,31.51) ; 116.2,20.94 P701.2 ; P701.2 117.53,22.27 ; P701.2 114.86,22.27 ; P701.2 116.2,23.61 ; 47,17.83 48.08,17.83 ; 47,17.83 45.92,17.83 ; 47,17.83 47,16.75 ; 47,17.83 47,18.91 ; 106.72,58.03 J401.5 ; J401.5 107.99,59.3 ; J401.5 109.26,58.03 ; 83.83,63.86 P501.1 ; P501.1 82.75,64.94 ; P501.1 84.91,64.94 ; P501.1 83.83,66.02 ; J401.3 113.07,64.38 ; J401.3 111.8,63.11 ; J401.3 114.34,63.11 ; J401.3 113.07,61.84 ; 50.24,62.4 P503.16 ; P503.16 51.32,63.48 ; P503.16 52.4,62.4 ; P503.16 51.32,61.32 ; 53.86,61.32 P503.14 ; P503.14 52.78,62.4 ; P503.14 54.94,62.4 ; P503.14 53.86,63.48 ; v1(62.62,32.75) 62.62,31.53 C652.2 62.56,31.54 v1(60.79,31.54) ; J401.2 109.26,63.11 ; J401.2 107.99,61.84 ; J401.2 106.72,63.11 ; J401.2 107.99,64.38 ; J401.4 114.34,58.03 ; J401.4 113.07,59.3 ; J401.4 111.8,58.03 ; P502.1 97.48,51.55 ; P502.1 95.32,51.55 ; P502.1 96.4,52.63 ; 63.98,30.7 P703.2 65.06,31.78 ; 100.88,15.16 P706.2 99.8,16.24 ; 99.8,34.18 P705.2 100.88,35.26 ; v1(82.54,34.4) v1(82.54,33.72) 82.88,34.06 C701.2 ; 63.98,24.75 P704.2 ; P704.2 65.06,25.83 ; P704.2 65.06,23.67 ; P704.2 66.14,24.75 ; v1(84.57,16.9) v1(85.31,16.9)
  BOTTOM w1.27: P704.2 64.75,25.07 C639.2
  vias: v1(0.27,72.88) v1(0.28,69.37) v1(0.27,49) v1(0.28,45.5) v1(0.27,25.13) v1(0.28,21.62) v1(0.32,60.94) v1(0.32,57.43) v1(0.32,37.07) v1(0.32,33.56) v1(1.04,72.1) v1(1.04,70.14) v1(1.08,60.17) v1(1.08,58.2) v1(1.04,48.23) v1(1.04,46.26) v1(1.08,36.29) v1(1.08,34.32) v1(1.04,24.35) v1(1.04,22.39) v1(2.33,72.13) v1(2.34,36.26) v1(2.48,46.26) v1(2.65,60.18) v1(2.62,48.2) v1(2.62,22.39) v1(3.03,58.22) v1(3.06,34.35) v1(3.19,70.14) v1(3.56,24.32) v1(4.08,72) v1(4.29,46.29) v1(4.88,36.26) v1(5.06,60) v1(5.16,48.2) v1(5.33,22.5) v1(5.42,34.35) v1(5.55,57.9) v1(5.71,69.88) v1(6.09,24.55) v1(6.6,71.67) v1(6.83,46.29) v1(7.42,36.45) v1(7.51,59.3) v1(7.6,65.13) v1(7.61,63.76) v1(7.6,53.19) v1(7.61,51.82) v1(7.6,41.25) v1(7.61,39.88) v1(7.6,29.32) v1(7.61,27.94) v1(7.7,48.2) v1(7.82,22.99) v1(7.9,56.94) v1(7.95,34.6) v1(8.05,62.62) v1(8.2,69.36) v1(8.37,30.55) v1(8.53,25.26) v1(9.08,71.11) v1(9.16,65.17) v1(9.16,53.23) v1(9.18,49.36) v1(9.16,41.29) v1(9.16,29.36) v1(9.19,63.75) v1(9.19,51.81) v1(9.19,39.87) v1(9.19,27.93) v1(9.8,58.08) v1(9.84,37.22) v1(9.93,55.41) v1(10,64.45) v1(10,52.51) v1(10.04,45.68) v1(10.06,44.2) v1(10,40.58) v1(10,28.64) v1(10.2,23.9) v1(10.38,35.36) v1(10.43,60.76) v1(10.43,32.8) v1(10.62,68.58) v1(10.59,66.96) v1(10.59,26.59) v1(11.49,70.3) v1(11.65,52.06) v1(11.63,50.62) v1(11.72,56.33) v1(11.73,53.62) v1(12.05,41.6) v1(12.05,40.16) v1(12.01,38.54) v1(12.49,58.51) v1(12.49,35.04) v1(12.4,25.17) v1(12.65,64.72) v1(12.61,50.03) v1(12.61,48.7) v1(12.6,36.59) v1(12.65,28.83) v1(12.86,27.89) v1(12.9,67.47) v1(13.07,45.68) v1(13.09,44.22) v1(13.53,51.82) v1(13.77,69.19) v1(13.71,54.35) v1(13.73,40.12) v1(14.42,26.7) v1(14.55,56.26) v1(14.55,37.29) v1(14.71,62.47) v1(14.71,31.08) v1(14.71,29.64) v1(14.98,66.01) v1(14.92,53.73) v1(15.06,38.65) v1(15.12,50.15) v1(15.52,41.97) v1(15.87,67.76) v1(15.93,74.19) v1(15.89,72.63) v1(15.96,44.89) v1(15.89,21.86) v1(15.93,20.3) v1(16.01,31.23) v1(16.27,49.31) v1(16.24,28.47) v1(16.61,71.79) v1(16.65,57.58) v1(16.6,54.01) v1(16.61,22.7) v1(16.77,60.22) v1(16.77,33.33) v1(16.69,24.34) v1(16.79,64.23) v1(16.96,52.88) v1(16.96,43.86) v1(16.96,42.34) v1(17.09,32.75) v1(17.31,74.18) v1(17.32,72.6) v1(17.32,21.89) v1(17.31,20.31) v1(17.47,49.39) v1(17.74,66.04) v1(17.73,38.65) v1(17.96,71.25) v1(18.17,34.27) v1(18.38,45.63) v1(18.36,37.32) v1(18.33,26.92) v1(18.41,62) v1(18.61,31.54) v1(18.83,57.98) v1(18.83,35.58) v1(19.12,68.44) v1(19.25,60.75) v1(19.34,64.07) v1(19.57,20.83) v1(19.97,29.49) v1(20,40.2) v1(20.13,81.51) v1(20.12,12.97) v1(20.27,59.29) v1(20.23,49.25) v1(20.29,65.62) v1(20.46,62.47) v1(20.46,34.15) v1(20.66,44.89) v1(20.9,80.75) v1(20.89,55.73) v1(20.89,37.82) v1(20.95,15.9) v1(20.9,13.74) v1(20.99,78.5) v1(21.21,23.4) v1(21.32,49.93) v1(21.41,74.22) v1(21.46,62.81) v1(21.41,18.4) v1(21.64,76.05) v1(21.6,60.88) v1(21.66,33.32) v1(21.6,32.06) v1(22.26,20.79) v1(22.57,71.4) v1(22.62,59.99) v1(22.74,73.76) v1(22.87,80.75) v1(22.86,79.44) v1(22.85,44.3) v1(22.81,33.89) v1(22.84,25.93) v1(22.88,15.59) v1(22.86,13.74) v1(23.11,77.72) v1(23.13,23.18) v1(23.19,17.57) v1(23.21,49.27) v1(23.25,47.79) v1(23.24,34.63) v1(23.64,81.51) v1(23.63,12.98) v1(23.74,68.58) v1(23.77,25.09) v1(23.82,71.46) v1(23.79,57.17) v1(23.89,19.67) v1(24.07,75.37) v1(24.4,34.04) v1(24.46,28.53) v1(24.58,21.45) v1(24.8,69.12) v1(24.88,37.2) v1(24.9,65.77) v1(25.19,73.09) v1(25.25,23.01) v1(25.47,28.05) v1(25.73,24.49) v1(25.98,29.89) v1(26.07,62.95) v1(26.17,65.16) v1(26.15,31.1) v1(26.21,70.76) v1(26.69,73.1) v1(26.75,19.96) v1(27.01,70.55) v1(27.01,23) v1(27.13,68.39) v1(27.28,67.52) v1(27.24,60.14) v1(27.73,33.63) v1(27.89,27.16) v1(27.95,72.63) v1(27.99,74.19) v1(28.05,65.87) v1(28.4,57.32) v1(28.67,71.79) v1(28.76,63.94) v1(28.77,29.13) v1(29.37,74.18) v1(29.38,72.6) v1(29.38,36.23) v1(29.55,61.04) v1(29.75,21.86) v1(29.79,20.3) v1(29.89,63.27) v1(29.92,57.81) v1(29.96,34.33) v1(29.96,30.26) v1(30.46,22.7) v1(30.57,66.85) v1(30.59,26.69) v1(31.19,38.55) v1(31.17,21.89) v1(31.16,20.31) v1(31.19,72.34) v1(31.28,63.25) v1(31.24,39.7) v1(31.2,34.33) v1(31.2,30.26) v1(31.31,57.79) v1(31.31,35.76) v1(31.46,69.3) v1(31.46,24.25) v1(32.07,57.3) v1(32.19,81.47) v1(32.52,60.12) v1(32.53,36.2) v1(32.75,33.04) v1(32.96,80.71) v1(32.98,79.69) v1(32.98,77.15) v1(32.98,74.61) v1(32.98,72.07) v1(32.98,69.53) v1(32.98,66.99) v1(32.9,64.16) v1(32.9,62.64) v1(32.9,61.37) v1(33.19,56.61) v1(33.16,36.88) v1(33.61,32.69) v1(33.97,13.02) v1(34.34,29.27) v1(34.43,32.24) v1(34.78,30.86) v1(34.77,28.14) v1(34.77,25.6) v1(34.77,23.06) v1(34.77,20.52) v1(34.77,17.98) v1(34.77,15.44) v1(34.75,13.78) v1(34.93,80.71) v1(34.9,78.82) v1(34.9,76.28) v1(34.9,73.74) v1(34.9,71.2) v1(34.9,68.66) v1(34.9,66.12) v1(35.25,61.31) v1(35.34,64.28) v1(35.7,81.47) v1(36.46,56.56) v1(36.49,36.94) v1(36.69,29.06) v1(36.76,32.59) v1(36.76,30.86) v1(36.69,27.27) v1(36.69,24.73) v1(36.69,22.19) v1(36.69,19.65) v1(36.69,17.11) v1(36.75,15.37) v1(36.72,13.78) v1(37.15,57.35) v1(37.48,13.02) v1(37.58,72.6) v1(37.66,33.19) v1(37.71,69.56) v1(37.84,66.51) v1(37.97,63.47) v1(38.11,60.42) v1(38.24,57.38) v1(38.43,39.7) v1(38.43,38.55) v1(38.64,19.82) v1(38.78,22.87) v1(38.91,25.91) v1(39.04,28.96) v1(39.18,32) v1(39.23,33.31) v1(39.31,35.05) v1(39.4,38.27) v1(39.63,36.14) v1(40.04,55.66) v1(40.65,36.14) v1(41.54,24.44) v1(41.7,53.46) v1(41.83,74.2) v1(41.84,42.41) v1(41.96,71.16) v1(42.1,68.11) v1(42.23,65.07) v1(42.36,62.02) v1(42.49,58.98) v1(42.63,55.93) v1(42.71,47.34) v1(43.03,21.26) v1(43.16,24.31) v1(43.32,48.86) v1(43.3,27.35) v1(43.43,30.4) v1(43.56,33.44) v1(43.62,46.4) v1(43.7,42.16) v1(43.69,36.49) v1(43.85,53.77) v1(43.83,39.54) v1(44.27,56.59) v1(44.89,62.59) v1(44.89,60.55) v1(44.89,58.52) v1(44.95,47.34) v1(45.07,64.61) v1(45.51,54.85) v1(45.64,48.84) v1(45.82,51.56) v1(45.89,66.47) v1(46.05,46.72) v1(46.57,56.3) v1(46.98,61.91) v1(46.99,58.08) v1(47.06,63.89) v1(47,60.01) v1(47.28,67.95) v1(47.4,48.86) v1(47.51,23.29) v1(47.51,22.28) v1(47.74,50.49) v1(47.76,47.42) v1(47.88,65.64) v1(48.53,24.31) v1(48.53,23.29) v1(48.53,22.28) v1(49.08,68.9) v1(49.14,66.6) v1(49.16,46.71) v1(49.32,45.02) v1(49.48,13.14) v1(49.55,24.31) v1(49.55,23.29) v1(50.05,41.32) v1(50.61,47.65) v1(51.09,69.19) v1(51.1,67.03) v1(51.26,41.08) v1(51.6,46.62) v1(51.6,42.82) v1(51.66,38.2) v1(52.32,39.52) v1(53.12,69.25) v1(53.37,48.63) v1(53.75,45.21) v1(53.88,16.47) v1(53.88,14.84) v1(54.32,46.62) v1(54.49,15.67) v1(54.83,42.15) v1(55.06,38.29) v1(55,36.77) v1(55.15,69.38) v1(55.1,16.49) v1(55.1,14.84) v1(55.39,39.17) v1(55.54,48.68) v1(55.53,45.07) v1(56.79,46.81) v1(56.9,41.24) v1(57.17,69.59) v1(57.46,48.68) v1(58.07,44.94) v1(58.1,43.17) v1(58.31,38.22) v1(58.44,35.97) v1(59.18,69.87) v1(59.13,41.58) v1(59.2,67.71) v1(59.33,46.81) v1(60,48.68) v1(60,44.94) v1(60.21,61.78) v1(60.44,39.33) v1(60.62,43.07) v1(61.18,70.22) v1(61.2,68.06) v1(61.58,35.59) v1(61.6,37.46) v1(61.87,46.81) v1(62.54,48.68) v1(62.54,44.94) v1(62.54,41.2) v1(62.92,61.51) v1(62.98,39.33) v1(63.17,70.65) v1(63.19,68.48) v1(63.16,43.07) v1(64.14,37.46) v1(64.12,35.59) v1(64.41,46.81) v1(65.08,48.68) v1(65.08,44.94) v1(65.08,41.2) v1(65.14,71.14) v1(65.16,68.98) v1(65.29,61.51) v1(65.52,39.33) v1(65.7,43.07) v1(66.68,37.46) v1(66.66,35.59) v1(66.95,46.81) v1(67.09,71.7) v1(67.11,69.54) v1(67.62,48.68) v1(67.62,44.94) v1(67.62,41.2) v1(67.83,61.51) v1(68.06,39.33) v1(68.24,43.07) v1(69.06,72.21) v1(69.08,70.04) v1(69.22,37.46) v1(69.2,35.59) v1(69.49,46.81) v1(70.16,44.94) v1(70.16,41.2) v1(70.24,61.13) v1(70.6,39.33) v1(70.78,43.07) v1(70.8,48.7) v1(71.05,72.64) v1(71.06,70.48) v1(71.41,24.12) v1(71.76,37.46) v1(71.74,35.59) v1(72.03,46.81) v1(72.7,44.94) v1(72.7,41.2) v1(72.97,48.69) v1(73.05,72.99) v1(73.06,70.83) v1(73.14,39.33) v1(73.19,24.12) v1(73.32,43.07) v1(74.05,58.89) v1(74.28,35.59) v1(74.3,37.46) v1(74.46,24.12) v1(74.57,46.81) v1(75.06,73.27) v1(75.08,71.11) v1(75.24,48.68) v1(75.24,44.94) v1(75.24,41.2) v1(75.68,39.33) v1(75.86,43.07) v1(76.11,24.12) v1(76.59,58.89) v1(76.84,37.46) v1(76.82,35.59) v1(77.08,73.47) v1(77.1,71.31) v1(77.11,46.81) v1(77.38,24.12) v1(77.78,48.68) v1(77.78,44.94) v1(77.78,41.2) v1(78.22,39.33) v1(78.4,43.07) v1(79.11,73.59) v1(79.13,71.43) v1(79.38,37.46) v1(79.36,35.59) v1(79.65,46.81) v1(79.87,61.53) v1(80.04,56.81) v1(80.32,48.68) v1(80.32,44.94) v1(80.32,41.2) v1(80.76,39.33) v1(80.94,43.07) v1(81.14,73.63) v1(81.16,71.47) v1(81.8,34.43) v1(81.83,33.69) v1(81.92,37.46) v1(81.9,35.59) v1(82.19,46.81) v1(82.86,48.68) v1(82.86,44.94) v1(82.86,41.2) v1(83.3,39.33) v1(83.48,43.07) v1(84.46,37.46) v1(84.44,35.59) v1(84.59,16.24) v1(84.73,46.81) v1(85.31,16.24) v1(85.4,48.68) v1(85.4,44.94) v1(85.4,41.2) v1(85.46,28.41) v1(85.46,27.14) v1(85.46,24.6) v1(85.46,23.33) v1(85.84,39.33) v1(86.02,43.07) v1(86.73,28.41) v1(86.73,27.14) v1(86.73,25.87) v1(86.73,24.6) v1(86.73,23.33) v1(86.82,76.17) v1(86.82,74.9) v1(86.82,73.63) v1(86.82,72.36) v1(86.82,71.09) v1(86.98,35.59) v1(87,37.46) v1(87.27,46.81) v1(87.94,48.68) v1(87.94,44.94) v1(87.94,41.2) v1(88,28.41) v1(88,27.14) v1(88,25.87) v1(88,24.6) v1(88,23.33) v1(88.09,76.17) v1(88.09,74.9) v1(88.09,73.63) v1(88.09,72.36) v1(88.38,39.33) v1(88.56,43.07) v1(89.27,28.41) v1(89.27,27.14) v1(89.27,25.87) v1(89.27,24.6) v1(89.27,23.33) v1(89.36,76.17) v1(89.36,74.9) v1(89.36,73.63) v1(89.36,72.36) v1(89.54,37.46) v1(89.52,35.59) v1(89.81,46.81) v1(90.48,48.68) v1(90.48,44.94) v1(90.48,41.2) v1(90.43,24.68) v1(90.54,28.41) v1(90.54,27.14) v1(90.54,25.87) v1(90.54,23.33) v1(90.63,76.17) v1(90.63,74.9) v1(90.63,73.63) v1(90.63,72.36) v1(90.63,71.09) v1(90.92,39.33) v1(91.1,43.07) v1(91.9,76.17) v1(91.9,74.9) v1(91.9,73.63) v1(91.9,72.36) v1(92.08,37.46) v1(92.06,35.59) v1(92.35,46.81) v1(93.02,44.94) v1(93.02,41.2) v1(93.48,48.69) v1(93.46,39.33) v1(93.64,43.07) v1(94.62,37.46) v1(94.6,35.59) v1(94.89,46.81) v1(95.56,44.94) v1(95.56,41.2) v1(95.64,48.66) v1(96,39.33) v1(96.18,43.07) v1(97.16,37.46) v1(97.14,35.59) v1(97.43,46.81) v1(98.1,44.94) v1(98.1,41.2) v1(98.32,48.69) v1(98.54,39.33) v1(99.02,35.59) v1(99.7,37.46) v1(99.97,43.07) v1(99.97,39.33) v1(100.19,46.82) v1(100.64,44.94) v1(100.64,41.2) v1(100.86,48.69) v1(101.56,35.59) v1(102.24,37.46) v1(102.51,43.07) v1(102.51,39.33) v1(102.73,46.82) v1(102.91,25.26) v1(103.18,44.94) v1(103.18,41.2) v1(103.4,48.69) v1(103.67,25.26) v1(104.1,35.59) v1(104.43,25.26) v1(104.78,37.46) v1(105.05,43.07) v1(105.05,39.33) v1(105.27,46.82) v1(105.19,25.26) v1(105.72,44.94) v1(105.72,41.2) v1(105.94,48.69) v1(105.96,25.26) v1(106.72,25.26) v1(106.94,35.61) v1(107.07,37.51) v1(107.2,46.78) v1(107.45,43.1) v1(107.48,25.26) v1(107.71,39.29) v1(107.96,45) v1(107.96,41.19) v1(108.24,25.26) v1(109.08,35.59) v1(109,25.26) v1(109.09,37.46) v1(109.37,46.81) v1(110.04,48.68) v1(110.04,44.94) v1(110.04,43.07) v1(110.04,41.2) v1(110.04,39.33) v1(111.63,37.46) v1(111.62,35.59) v1(112.53,46.74) v1(112.57,42.92) v1(112.57,39.14) v1(112.89,44.76) v1(113.3,40.92) v1(113.93,35.86) v1(114.19,48.75) v1(114.26,37.42) v1(114.37,41.58) v1(114.47,45.37) v1(115.39,44.31) v1(115.77,40.33) v1(116.28,41.89) v1(116.64,38) v1(116.98,47.61) v1(117,39.88) v1(117.23,36.37) v1(117.41,49.83) v1(117.47,45.55) v1(117.56,68.91) v1(117.5,41.7) v1(118.04,43.98) v1(118.27,48.52) v1(118.37,35.35) v1(119.15,40.92) v1(119.4,48.78) v1(119.73,36.38) v1(119.86,46.8) v1(119.92,44.76) v1(120.1,51.48) v1(120.16,42.59) v1(121.17,37.58) v1(121.84,48.49) v1(121.94,41.6) v1(122.2,43.63) v1(122.43,36.94) v1(123.14,46.84) v1(123.38,42.92) v1(123.48,53.14) v1(123.54,51.45) v1(123.6,40.61) v1(124.04,36.05) v1(124.09,27.99) v1(124.38,44.49) v1(124.34,21.64) v1(124.41,33.96) v1(124.52,45.97) v1(124.6,68.96) v1(124.83,48.7) v1(124.95,67.46) v1(125.56,41.62) v1(126.06,33) v1(126.25,19.86) v1(126.37,44.48) v1(126.44,46.82) v1(126.63,13.13) v1(126.79,37.21) v1(127.05,42.96) v1(127.16,50.72) v1(127.19,52.97) v1(127.82,40.47) v1(127.94,45.96) v1(128.53,16.3) v1(128.68,42.14) v1(128.75,55.57) v1(129.04,44.91) v1(129.04,31.92) v1(129.26,36.39) v1(129.4,48.41) v1(129.55,49.95) v1(130.06,21.64) v1(130.13,43.15) v1(130.44,13.13) v1(130.91,41.18) v1(131.07,48.43) v1(131.07,46.15) v1(134.25,13.13) v1(138.06,19.48) v1(138.06,13.13) v1(141.87,19.48) v1(141.87,16.3) v1(141.87,13.13) v1(145.68,19.48) v1(145.68,16.3) v1(145.68,13.13) v2(135.29,70.74) v2(135.29,55.5) v2(139.1,56.77) v2(140.37,56.77) v2(140.37,51.69) v2(141.65,46.65) v2(142.86,42.8) v2(145.35,43.73) v2(145.93,58.21) v2(145.92,56.86) v2(145.92,54.32) v2(145.92,51.78) v2(145.92,49.24) v2(146.06,59.27) v2(147.87,70.73) v2(147.87,65.65) v2(147.84,60.59) v2(147.87,45.35) v2(147.87,40.25) v2(147.87,35.17) v3(8.9,46.27) v3(10.04,48.18) v3(11.57,46.27) v3(14.36,48.18) v3(14.36,46.27) v3(16.52,48.18) v3(21.9,54.45) v3(22.34,39.44) v3(23.07,53.64) v3(23.28,40.15) v3(23.53,36.27) v3(23.89,52.52) v3(24.09,41.19) v3(24.47,56.18) v3(24.75,54.94) v3(24.85,38.76) v3(25.08,51.33) v3(25.08,42.21) v3(25.56,53.84) v3(25.66,39.82) v3(26.27,50.44) v3(26.32,43.15) v3(26.55,52.85) v3(26.53,40.66) v3(27.39,43.76) v3(27.59,52.07) v3(27.82,41.58) v3(30.62,41.07) v3(30.97,48.99) v3(31.07,50.26) v3(31.02,46.76) v3(31.05,44.8) v3(31.25,64.31) v3(31.38,51.38) v3(31.96,52.45) v3(32.06,46.27) v3(32.44,54.94) v3(32.93,53.51) v3(32.93,46.43) v3(33.08,48.84) v3(33.13,49.98) v3(33.23,59.76) v3(33.23,58.26) v3(33.47,60.97) v3(33.56,51.05) v3(34.02,54.35) v3(34.48,52.12) v3(35.26,54.99) v3(35.39,52.73) v3(35.89,47.12) v3(36.08,49.65) v3(36.1,50.62) v3(36.36,53.18) v3(38.19,55.53) v3(40.65,36.14) v3(41.33,38.2) v3(41.82,39.19) v3(43.85,38.78) v3(43.93,38.02) v3(118.25,27.99) v3(121.8,24.3) v3(126.12,27.99) v3(126.12,24.3) v4(18.04,48.18) v4(18.17,46.27) v4(23.5,45.13) v4(25.03,47.8) v4(25.16,46.66) v4(27.8,49.65) v4(33.03,47.67) v4(39.89,52.5) v5(41.03,48.74) v5(43.44,50.34) v5(43.95,52.12) v5(47,42.59) v5(47.38,45.13) v5(50.38,49.17) v5(51.85,44.22) v5(52.84,45.26) v5(54.67,43.58) v5(119.72,38.53) v5(124.11,38.58) v5(125.21,39.57) v5(126.25,34.64) v5(127.14,38.81) v5(128.74,33.6) v5(130.39,37.99) v5(131.4,32.91) v5(133.99,37.77) v5(135.26,50.34) v5(135.26,45.26) v5(136.58,37.74) v5(136.69,39.04) v5(137.8,49.2) v5(139.07,37.77) v5(141.61,39.04) v5(144.31,44.45) v5(145.22,33.83) v5(145.3,39.14) v6(41.03,48.74) v8(11.73,53.62) v8(13.53,51.82) v8(13.71,54.35) v8(20.76,40.66) v8(21.75,40.48) v8(22.72,43.4) v8(22.89,40.84) v8(23.25,50.47) v8(23.55,52.57) v8(23.91,43.51) v8(24.29,49.76) v8(24.47,41.35) v8(24.77,51.99) v8(24.94,44.25) v8(25.33,49.03) v8(25.5,42.09) v8(25.8,51.25) v8(25.98,44.99) v8(26.36,48.29) v8(26.53,42.83) v8(26.84,50.51) v8(27.01,45.72) v8(27.14,47.75) v8(27.57,43.56) v8(27.97,46.15) v8(34.77,28.14) v8(34.77,25.6) v8(36.69,29.06) v8(36.69,27.27) v8(36.69,24.73) v8(38.9,37.49) v8(47.96,40.53) v8(48.02,42.23) v8(128.91,52.75) v8(130.44,51.1) v8(133.99,63.29) v8(135.39,68.37) v8(135.65,63.29) v8(136.41,69.9) v8(137.04,68.25) v8(137.55,71.17) v8(137.8,48.05) v8(138.06,59.36) v8(138.69,70.15) v8(139.07,71.93) v8(140.6,43.86) v8(140.78,65.58) v8(141.11,52.88) v8(142.76,67.1) v8(144.79,40.43) v8(144.92,71.17) v8(144.92,69.52) v8(144.92,35.35) v8(146.19,40.94)
